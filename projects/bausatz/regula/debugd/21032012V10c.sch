# EAGLE board 21032012V10c (EAGLE 5.07), part 1 of 2

Size 279.4 x 114.3 mm. Coordinates in mm from the lower left corner, seen from the top.
Outline: 279.4,0 279.4,114.3 0,114.3 0,0 279.4,0
Copper layers (1*16): Top 0.035mm / dielectric 1.5mm / Bottom 0.035mm
Design rules "default *": minimum track width 10mil, minimum drill 24mil, track to track 8mil, track to pad 8mil, pad to pad 8mil, via to via 8mil, smd to smd 8mil, copper to edge 40mil, drill to drill 8mil, minimum pad ring 1mil, minimum via ring 8mil, stop-mask expansion 4mil, vias tented up to drill 0mil, thermal gap 10mil
Holes 2.2 mm at 6.35,5.08 46.99,45.72 6.35,52.7 46.99,5.08 6.35,98.42 46.99,98.42

## Footprints (pad centres in the part's own frame; a part is rotated, then mirrored left to right if it is on the bottom)
TO220ACS = drill 1.016 long: A 2.54,-2.54; C -2.54,-2.54
LED3MM = drill 0.813 octagon: A -1.27,0; K 1.27,0
SMB = smd 2.4 x 2.4: A 2.2,0; C -2.2,0
E5-8,5 = drill 1.016 pad 2.54 round: + -2.54,0 | drill 1.016 pad 2.54 octagon: - 2.54,0
E2,5-6 = drill 0.813 pad 1.6 round: + -1.27,0 | drill 0.813 pad 1.6 octagon: - 1.27,0
E5-6 = drill 0.813 pad 1.905 round: + -2.54,0 | drill 0.813 pad 1.905 octagon: - 2.54,0
C1206 = smd 1.6 x 1.8: 1 -1.4,0; 2 1.4,0
TO247S = drill 1.499 long: 1 -5.588,-2.921; 2 0,-2.921; 3 5.588,-2.921
DPACK = smd 1.6 x 3: 1 -2.28,-4.8; 3 2.28,-4.8 | smd 5.8 x 6.2: 4 0,2.38
SO08 = smd 0.6 x 2.2: 1 -1.905,-2.6; 2 -0.635,-2.6; 3 0.635,-2.6; 4 1.905,-2.6; 5 1.905,2.6; 6 0.635,2.6; 7 -0.635,2.6; 8 -1.905,2.6
317TS = drill 1.016 long: 1 -2.54,-2.54; 2 0,-2.54; 3 2.54,-2.54
MINIMELF = smd 1.4 x 1.8: A 1.7,0; C -1.7,0
SOT23-BEC = smd 1 x 1.4: B -0.95,-1.1; C 0,1.1; E 0.95,-1.1
R5025 = smd 1.8 x 2.7: 1 -2.2,0; 2 2.2,0
R1206 = smd 1.6 x 1.803: 1 -1.422,0; 2 1.422,0
R1210 = smd 1.6 x 2.7: 1 -1.4,0; 2 1.4,0
EVND8AA = drill 1 pad 1.778 long: A -2.5,-2.5; E 2.5,-2.5; S 0.04,2.54
SOT23 = smd 1 x 1.4: 1 -0.95,-1.1; 2 0.95,-1.1; 3 0,1.1
SOD80C = smd 1.4 x 1.8: A 1.7,0; C -1.7,0
SOT223 = smd 1.219 x 2.235: 1 -2.311,-3.099; 2 0,-3.099; 3 2.311,-3.099 | smd 3.6 x 2.2: 4 0,3.099
FUSE_HOLDER_5X20MM = drill 1.422 pad 2.286 square: 1 0,0; 2 15.24,0
SHK20Q = drill 1.5 pad 3.81 octagon: 1A -7.874,2.54; 1B -7.874,-2.54; 2A 7.874,2.54; 2B 7.874,-2.54
DIL8 = drill 0.813 long: 1 -3.81,-3.81; 2 -1.27,-3.81; 3 1.27,-3.81; 4 3.81,-3.81; 5 3.81,3.81; 6 1.27,3.81; 7 -1.27,3.81; 8 -3.81,3.81
TO92S = drill 0.6 pad 0.813 long: 1 -1.27,0; 2 0,0; 3 1.27,0
1X1MM8 = drill 1.6 pad 2.54 octagon: 1 0,0
L5650M = smd 1.8 x 4: 1 -2.5,0; 2 2.5,0
P-LCC-4-3 = smd 3.3 x 4.8: 1 -2,-3.15; 2 -2,3.15; 3 2,3.15; 4 2,-3.15
CHIPLED_1206 = smd 1.5 x 1.5: A 0,-1.75; C 0,1.75
1X4MM5 = drill 4.5 pad 6.35 round: 1 0,0
1X01 = drill 1.016 octagon: 1 0,0
SMD4 = smd 1.78 x 1.55: 1 -1.27,-3.5; 2 1.27,-3.5; 3 1.27,3.5; 4 -1.27,3.5
1X01' = drill 1.016 square: 1 0,0
SOT93V = drill 1.397 long: B -5.461,-2.54; C 0,-2.54; E 5.461,-2.54
TO220AV = drill 1.016 long: B -2.54,-2.54; C 0,-2.54; E 2.54,-2.54
D-PAK_TO252AA = smd 1 x 1.6: 1 -2.28,-4.8; 3 2.28,-4.8 | smd 5.4 x 6.2: 4 0,2.5
TO252 = smd 1 x 1.6: 1 -2.28,-4.8; 2 2.28,-4.8 | smd 5.4 x 6.2: 3 0,2.5
TO126AV = drill 1.016 long: B 2.286,-1.27; C 0,-1.27; E -2.286,-1.27
R2010 = smd 1.8 x 2.7: 1 -2.2,0; 2 2.2,0
CERAM55 = drill 1 pad 2.54 octagon: 1 -22.86,0; 2 22.86,0
0207/15 = drill 0.813 octagon: 1 -7.62,0; 2 7.62,0
RANDL = drill 0.9 long: A -4,5; E 4,5; S 0,5 | drill 1 square: P$1 -5,-5; P$2 5,-5
320NEW = drill 1.8 pad 3.81 octagon: 1 -4.928,7.823; 2 -4.928,0; 3 -4.928,-7.823; 4 4.928,7.823; 5 4.928,0; 6 4.928,-7.823
KSS1201 = drill 0.914 pad 2.159 octagon: + 3.251,0; - -3.251,0
S64W = drill 0.7 long: A 2.54,1.27; E -2.54,1.27; S 0,1.27
SOT23-6 = smd 0.635 x 1.27: 1 -1.016,-1.016; 2 0,-1.016; 3 1.016,-1.016; 4 1.016,1.016; 5 0,1.016; 6 -1.016,1.016
TO3-K02 = drill 1.194 pad 3.81 octagon: 1 -1.778,-5.461; 2 -1.778,5.461 | drill 4.115 pad 6.477 round: 3 15.113,0; 3@ -15.113,0
0204V = drill 0.813 octagon: 1 -1.27,0; 2 1.27,0
C050-025X075 = drill 0.813 octagon: 1 -2.54,0; 2 2.54,0
R0402 = smd 0.7 x 0.9: 1 -0.65,0; 2 0.65,0
1X02 = drill 1.016 square: 1 -1.27,0 | drill 1.016 octagon: 2 1.27,0
0204/5 = drill 0.813 octagon: 1 -2.54,0; 2 2.54,0
0617/17 = drill 1.016 octagon: 1 -8.89,0; 2 8.89,0
R0805 = smd 1.3 x 1.5: 1 -0.95,0; 2 0.95,0

## Placement (x,y rotation side)
A  [TO220ACS]  9.84,34.61 270 top
A..C  [LED3MM]  10.79,41.27 180 top
C  [SMB]  8.89,33.97 270 top
C1  [E5-8,5]  32.38,57.78 0 top
C2  [E2,5-6]  33.24,88.84 90 top
C3  [E2,5-6]  24.77,87.63 0 top
C4  [E5-6]  33.66,15.24 270 top
C5  10n  [C1206]  267.33,19.05 90 top
C6  [SMB]  101.6,86.36 0 top
C7  [C1206]  158.75,82.55 270 top
C9  [E5-6]  145.41,90.81 90 top
C10  [E2,5-6]  104.78,93.98 270 top
C-1083  LT1083CP-V  [TO247S]  43.18,26.04 270 top
C-MABDT  LM317MABDT  [DPACK]  25.72,49.53 90 top
C-MABDT1  LM317MABDT  [DPACK]  37.72,82.87 270 top
C-SO1  [SO08]  24.13,60.96 180 top
C-SO8  [SO08]  31.11,35.56 180 top
C-TS  [317TS]  42.8,26.04 270 top
C.  1N4148MINIMELF  [MINIMELF]  8.57,33.97 270 top
C.1  1N4148MINIMELF  [MINIMELF]  37.47,40.64 270 top
CQ3  BC817-40LT1SMD  [SOT23-BEC]  38.54,88.65 90 top
CR1  [R5025]  19.05,38.1 180 top
CR2  [R1206]  27.3,35.56 270 top
CR3  [R1206]  22.54,21.59 90 top
CR4  [R1206]  36.83,44.45 180 top
CR5  [R1210]  24.38,35.56 270 top
CTRIM3  [EVND8AA]  13.92,15.24 90 top
D1  [MINIMELF]  20.95,43.81 180 top
D2  [MINIMELF]  37.91,91.25 0 top
D3  [MINIMELF]  18.73,83.19 180 top
D4  BAS40-04  [SOT23]  12.06,25.4 270 top
D5  [MINIMELF]  15.24,96.52 180 top
D6  [MINIMELF]  34.29,93.34 0 top
D7  [MINIMELF]  30.48,89.53 90 top
D8  [MINIMELF]  85.09,18.1 0 top
D9  [MINIMELF]  91.44,12.7 90 top
D9A  [MINIMELF]  92.08,18.41 0 top
D10  [MINIMELF]  71.75,13.97 90 top
D10A  [MINIMELF]  73.03,18.41 0 top
D10A1  [MINIMELF]  86.36,12.7 270 top
D11  [MINIMELF]  98.42,80.64 0 top
D12  [MINIMELF]  123.83,18.1 180 top
D13  [MINIMELF]  125.09,12.7 90 top
D14  [MINIMELF]  110.49,12.7 90 top
D15  [MINIMELF]  111.12,18.41 0 top
D16  [SOD80C]  267.33,13.34 270 top
D17  [MINIMELF]  104.14,18.1 0 top
D18  [MINIMELF]  105.41,12.7 270 top
D19  [MINIMELF]  163.19,12.06 270 top
D20  [MINIMELF]  161.93,17.78 0 top
D21  [MINIMELF]  201.29,12.7 270 top
D22  [MINIMELF]  200.03,18.41 0 top
D23  [MINIMELF]  239.4,12.06 270 top
D24  [MINIMELF]  238.12,18.1 0 top
D25  [MINIMELF]  149.22,18.41 0 top
D26  [MINIMELF]  149.22,12.06 90 top
D27  [MINIMELF]  187.96,18.41 0 top
D28  [MINIMELF]  186.06,12.7 90 top
D29  [MINIMELF]  225.04,18.48 0 top
D30  [MINIMELF]  224.16,12.7 90 top
D31  [MINIMELF]  6.35,26.67 90 top
D33  [MINIMELF]  142.88,18.1 0 top
D34  [MINIMELF]  144.15,12.7 270 top
D35  [MINIMELF]  129.54,12.7 90 top
D36  [MINIMELF]  130.18,18.41 0 top
D37  [MINIMELF]  182.25,12.7 270 top
D38  [MINIMELF]  180.97,18.1 0 top
D39  [MINIMELF]  220.34,12.7 270 top
D40  [MINIMELF]  219.07,18.1 0 top
D41  [MINIMELF]  258.44,12.06 270 top
D42  [MINIMELF]  257.18,18.1 0 top
D43  [MINIMELF]  168.28,18.41 0 top
D44  [MINIMELF]  167.64,13.34 90 top
D45  [MINIMELF]  205.93,18.41 0 top
D46  [MINIMELF]  205.74,12.7 90 top
D47  [MINIMELF]  244.47,18.41 0 top
D48  [MINIMELF]  243.21,12.06 90 top
D49  [MINIMELF]  8.89,26.67 90 top
DISP_R  [R1206]  123.83,97.79 0 top
DISP_R1  [R1206]  161.29,81.92 90 top
DISP_V  BCX56  [SOT223]  125.09,85.09 0 top
DISP_Z  [MINIMELF]  124.46,94.61 0 top
DISP_Z1  [MINIMELF]  144.78,81.28 270 top
DISP_Z2  [MINIMELF]  142.24,83.82 270 top
DISP_Z3  [MINIMELF]  164.47,81.92 90 top
F1  FUSEBLANK_5X20MM  [FUSE_HOLDER_5X20MM]  8.89,92.71 270 top
F2  [SHK20Q]  270.51,59.69 90 top
IC1  PIC12F675P  [DIL8]  155.57,90.81 0 top
IC2  [TO92S]  31.11,35.56 0 top
JP1  [1X1MM8]  36.2,47.62 0 top
L1  [L5650M]  97.16,93.98 90 top
L2  [L5650M]  90.81,93.98 270 top
LED3  [P-LCC-4-3]  134.62,89.53 0 top
LED4  [CHIPLED_1206]  155.57,22.23 180 top
LED5  [CHIPLED_1206]  193.68,22.86 180 top
LED6  [CHIPLED_1206]  231.78,22.86 180 top
LED7  [CHIPLED_1206]  136.53,22.23 180 top
LED8X  [CHIPLED_1206]  117.47,22.23 180 top
LED9  [CHIPLED_1206]  174.62,22.23 180 top
LED9X  [CHIPLED_1206]  98.42,22.23 180 top
LED10  [CHIPLED_1206]  212.72,22.86 180 top
LED10X  [CHIPLED_1206]  79.38,22.23 180 top
LED11  [CHIPLED_1206]  250.82,22.86 180 top
MINU1S  [1X4MM5]  241.3,5.08 0 top
MINUS0S  [1X4MM5]  260.35,5.08 0 top
MINUS0X1  [1X01]  256.54,6.35 0 top
MINUS1X  [1X01]  236.22,6.99 0 top
MINUS2  [1X4MM5]  222.25,5.08 0 top
MINUS2X1  [1X01]  218.44,3.17 0 top
MINUS3S  [1X4MM5]  203.2,5.08 0 top
MINUS3X  [1X01]  198.12,5.08 0 top
MINUS4S  [1X4MM5]  184.15,5.08 0 top
MINUS4X4  [1X01]  179.07,5.08 0 top
MINUS5S  [1X4MM5]  165.1,5.08 0 top
MINUS5X2  [1X01]  159.38,5.08 0 top
MINUS6S  [1X4MM5]  146.05,5.08 0 top
MINUS6X2  [1X01]  140.34,4.45 0 top
MINUS8  [1X4MM5]  127,5.08 0 top
MINUS8X  [1X01]  119.38,4.45 0 top
MINUS9  [1X4MM5]  107.95,5.08 0 top
MINUS9X1  [1X01]  102.23,4.45 0 top
MINUS10  [1X4MM5]  88.9,5.08 0 top
MINUS10X  [1X01]  83.82,5.08 0 top
MINUS60  [1X4MM5]  256.62,97.08 0 top
MINUS120  [1X4MM5]  218.62,97.08 0 top
OK1X  SFH6186-2  [SMD4]  257.18,24.13 0 top
OK2  SFH6186-2  [SMD4]  74.3,95.25 90 top
OK2X  SFH6186-2  [SMD4]  238.12,24.13 0 top
OK3  SFH6186-2  [SMD4]  219.07,24.13 0 top
OK4X  SFH6186-2  [SMD4]  200.03,24.13 0 top
OK5X  SFH6186-2  [SMD4]  180.97,24.13 0 top
OK6X  SFH6186-2  [SMD4]  161.93,24.13 0 top
OK7  SFH6186-2  [SMD4]  142.88,24.13 0 top
OK8X  SFH6186-2  [SMD4]  123.83,24.13 0 top
OK9X  SFH6186-2  [SMD4]  104.78,24.13 0 top
OK10X  SFH6186-2  [SMD4]  85.72,24.13 0 top
OUT+  [1X01']  6.35,44.45 0 top
PLUS11  [1X4MM5]  69.85,5.08 0 top
PLUS11X  [1X01]  69.85,0.64 0 top
PLUS120  [1X4MM5]  237.62,97.08 0 top
PS_BOT  [C1206]  72.39,90.81 180 top
PS_EMIT  [R1210]  75.56,85.72 0 top
PS_TOP  [C1206]  67.31,90.81 180 top
PS_ZEN_FB  [MINIMELF]  84.45,95.25 270 top
Q1  TIP142SOT93V  [SOT93V]  78.74,41.91 0 top
Q1T  TIP120TO220V  [TO220AV]  78.74,41.91 0 top
Q2  TIP41C  [TO220AV]  21.59,101.6 0 top
Q2S  TIP120  [D-PAK_TO252AA]  97.79,46.99 0 top
Q2T  TIP120TO220V  [TO220AV]  97.79,41.91 0 top
Q3  TIP120  [D-PAK_TO252AA]  116.84,48.26 0 top
Q4  BC807-40SMD  [SOT23-BEC]  268.61,24.13 0 top
Q5  FDD4141TO252  [TO252]  270.51,42.55 0 top
Q6  BC857CSMD  [SOT23-BEC]  85.09,86.36 270 top
Q7  TIP120  [D-PAK_TO252AA]  231.14,48.26 0 top
Q8  TIP120  [D-PAK_TO252AA]  193.04,48.26 0 top
Q9  TIP120  [D-PAK_TO252AA]  154.94,48.26 0 top
Q10  BC857  [SOT223]  92.71,86.36 270 top
Q10S  TIP120  [D-PAK_TO252AA]  78.74,48.26 0 top
Q11  BC847ALT1SMD  [SOT23]  111.12,80.64 0 top
Q12  BD139  [TO126AV]  42.55,38.73 270 top
Q13  BD139  [TO126AV]  42.55,47.62 270 top
Q14  BC857CSMD  [SOT23-BEC]  73.03,25.4 180 top
Q15  TIP120TO220V  [TO220AV]  116.84,41.91 0 top
Q16  TIP120TO220V  [TO220AV]  154.94,41.91 0 top
Q17  TIP120TO220V  [TO220AV]  193.04,41.91 0 top
Q18  TIP120TO220V  [TO220AV]  231.14,41.91 0 top
Q19  BC857CSMD  [SOT23-BEC]  92.08,25.4 180 top
Q20  TIP120  [D-PAK_TO252AA]  135.89,48.26 0 top
Q21  TIP142SOT93V  [SOT93V]  116.84,41.91 0 top
Q22  TIP120TO220V  [TO220AV]  135.89,41.91 0 top
Q23  TIP120  [D-PAK_TO252AA]  250.19,48.26 0 top
Q24  TIP120  [D-PAK_TO252AA]  212.09,48.26 0 top
Q25  TIP120  [D-PAK_TO252AA]  173.99,48.26 0 top
Q26  TIP120TO220V  [TO220AV]  173.99,41.91 0 top
Q27  TIP120TO220V  [TO220AV]  212.09,41.91 0 top
Q28  TIP120TO220V  [TO220AV]  250.19,41.91 0 top
Q29  TIP142SOT93V  [SOT93V]  97.79,41.91 0 top
Q30  BC857CSMD  [SOT23-BEC]  111.12,25.4 180 top
Q31  BC857CSMD  [SOT23-BEC]  130.18,25.4 180 top
Q32  BC857CSMD  [SOT23-BEC]  149.22,25.4 180 top
Q33  BC857CSMD  [SOT23-BEC]  168.28,25.4 180 top
Q34  BC857CSMD  [SOT23-BEC]  187.32,25.4 180 top
Q35  BC857CSMD  [SOT23-BEC]  205.74,25.4 180 top
Q36  BC857CSMD  [SOT23-BEC]  224.79,25.4 180 top
Q37  BC857CSMD  [SOT23-BEC]  243.84,25.4 180 top
Q38  TIP142SOT93V  [SOT93V]  135.89,41.91 0 top
Q39  TIP142SOT93V  [SOT93V]  154.94,41.91 0 top
Q40  TIP142SOT93V  [SOT93V]  173.99,41.91 0 top
Q41  TIP142SOT93V  [SOT93V]  193.04,41.91 0 top
Q42  TIP142SOT93V  [SOT93V]  212.09,41.91 0 top
Q43  TIP142SOT93V  [SOT93V]  231.14,41.91 0 top
Q44  TIP142SOT93V  [SOT93V]  250.19,41.91 0 top
R1  [R2010]  42.04,89.92 90 top
R2  [CERAM55]  78.74,50.16 270 top
R3  [CERAM55]  97.79,50.16 270 top
R4  [CERAM55]  116.84,50.16 270 top
R5  [CERAM55]  135.89,50.16 270 top
R6  0  [0207/15]  270.51,60.33 270 top
R7  270k  [R1206]  270.51,31.11 180 top
R8  180k  [R1206]  266.7,32.38 270 top
R9  120k  [R1206]  271.14,27.94 0 top
R10  33k  [R1206]  271.14,34.29 180 top
R11  14/3m  [R1206]  271.14,12.06 180 top
R12  0.6/200u  [R1206]  271.14,15.24 0 top
R13  [CERAM55]  173.99,50.16 270 top
R14  [CERAM55]  154.94,50.16 270 top
R15  [EVND8AA]  150.11,82.11 270 top
R16  [CERAM55]  193.04,50.16 270 top
R18  [CERAM55]  231.14,50.16 270 top
R21  [CERAM55]  212.09,50.16 270 top
R22  [RANDL]  11.43,15.24 270 top
R24  [CERAM55]  250.19,50.16 270 top
S1  [320NEW]  186.06,97.79 0 top
SP1  KSS1201  [KSS1201]  167.64,90.53 270 top
T1  BC846  [SOT23]  271.78,19.68 0 top
TO92S  [TO92S]  24.13,60.96 0 top
TRIM0-9  [S64W]  250.82,13.34 180 top
TRIM1-9  [S64W]  231.78,13.34 180 top
TRIM2-7  [S64W]  174.62,13.34 180 top
TRIM2-9  [S64W]  212.72,13.34 180 top
TRIM3-9  [S64W]  193.68,13.34 180 top
TRIM5X  [S64W]  155.57,13.34 180 top
TRIM7X  [S64W]  136.53,13.34 180 top
TRIM8X  [S64W]  117.47,13.34 180 top
TRIM9X  [S64W]  98.42,13.34 180 top
TRIM10X  [S64W]  79.38,13.34 180 top
U$1  BCX56  [SOT223]  111.12,85.72 0 top
U$2  PIC10F204OT  [SOT23-6]  151.76,90.81 180 top
V-1083  LT1083CP-V  [TO247S]  43.18,66.36 270 top
V-TO1  [TO3-K02]  25.04,36.83 225 bottom
V-TO3  [TO3-K02]  25.13,77.11 225 bottom
V-TS  [317TS]  43.18,66.36 270 top
V_C_IN(+)  [1X01]  38.73,47.62 270 top
V_OPTION  [0204V]  19.37,58.55 180 top
VC1  [C050-025X075]  34.29,98.74 0 top
VC2  [C050-025X075]  26.99,95.19 0 top
VC3  [C050-025X075]  19.43,41.15 180 top
VC4  [C1206]  14.61,80.01 180 top
VCBRIDGE1  [R0402]  38.1,50.16 270 top
VENT_RB  [R1206]  106.05,81.28 270 top
VENT_RT  [R1206]  90.81,80.64 0 top
VENTI  [1X02]  114.94,93.98 270 top
VIN(+)  [1X1MM8]  21.59,93.98 270 top
VIN(-)  [1X01']  40.64,96.52 270 top
VIN(-)1  [1X01']  30.48,10.16 270 top
VIN+1  [1X01']  21.59,91.44 270 top
VOUT(+)  [1X01]  6.35,40.64 270 top
VOUT(+)1  [1X01]  237.49,109.86 0 top
VOUT(+)REG  [1X01]  40.64,53.34 270 top
VOUT-  [1X01]  40.64,57.15 180 top
VPOT1  [RANDL]  11.43,62.55 270 top
VPOT2  [S64W]  15.24,62.55 270 top
VR1  390  [0207/15]  21.59,69.53 180 top
VR2  [0204V]  32.38,78.42 180 top
VR3  [0204/5]  28.26,88.96 270 top
VR4  [R1206]  12.06,73.03 0 top
VR5  [R1206]  21.59,66.04 180 top
VR6  [R1206]  20.32,62.23 90 top
VR7  [R1206]  28.26,88.9 270 top
VR8  [R1206]  32.83,76.83 180 top
VR9  [R1206]  20.32,96.52 0 top
VR10  [0617/17]  46.35,83.82 90 top
VR11  [R1206]  74.3,22.23 0 top
VR12  [R1206]  112.39,22.23 0 top
VR13  [R1206]  79.38,8.26 0 top
VR14  [R1206]  81.92,22.86 90 top
VR15  [R0805]  99.06,18.1 180 top
VR16  [R1206]  67.94,95.25 270 top
VR17  [R1206]  132.72,80.01 0 top
VR18  [R1206]  137.79,97.79 0 top
VR19  [R1206]  138.43,80.01 0 top
VR20  [R1206]  131.44,22.23 0 top
VR21  [R1206]  98.42,8.26 0 top
VR22  [R1206]  77.47,90.81 0 top
VR23  [R1206]  80.64,95.25 90 top
VR24  [R1206]  100.97,23.5 90 top
VR25  [R1206]  150.5,22.23 0 top
VR26  [R1206]  189.23,22.23 0 top
VR27  [R1206]  226.06,22.23 180 top
VR28  [R1206]  118.11,8.26 0 top
VR29  [R1206]  120.02,24.13 90 top
VR30  [R1206]  158.12,24.13 90 top
VR31  [R1206]  196.22,24.13 90 top
VR32  [R1206]  234.31,24.13 90 top
VR33  [R1206]  193.68,8.26 0 top
VR34  [R1206]  231.14,8.26 0 top
VR35  [R1206]  155.57,8.26 0 top
VR36  [R1206]  137.16,8.26 0 top
VR37  [R1206]  139.06,24.13 90 top
VR38  [R1206]  169.54,22.23 0 top
VR39  [R1206]  207.01,22.23 0 top
VR40  [R1206]  245.75,22.23 0 top
VR41  [R1206]  177.16,24.13 90 top
VR42  [R1206]  215.26,24.13 90 top
VR43  [R1206]  253.37,24.13 90 top
VR44  [R1206]  212.72,8.26 0 top
VR45  [R1206]  250.19,8.26 0 top
VR46  [R1206]  174.62,8.26 0 top
VR47  [R0805]  81.92,15.88 180 top
VR48  [R0805]  76.2,15.88 180 top
VR49  [R0805]  80.01,18.1 0 top
VR50  [R0805]  100.97,15.88 180 top
VR51  [R0805]  95.25,15.88 0 top
VR52  [R1206]  93.34,22.23 0 top
VR53  [R0805]  120.65,15.88 180 top
VR54  [R0805]  114.3,15.88 0 top
VR55  [R0805]  118.75,18.1 180 top
VR56  [R0805]  139.7,15.88 180 top
VR57  [R0805]  133.35,15.88 0 top
VR58  [R0805]  137.79,18.1 180 top
VR59  [R0805]  158.75,15.88 180 top
VR60  [R0805]  152.4,15.88 0 top
VR61  [R0805]  156.84,18.41 180 top
VR62  [R0805]  177.8,15.88 180 top
VR63  [R0805]  171.45,15.88 0 top
VR64  [R0805]  175.9,18.1 180 top
VR65  [R0805]  196.85,15.88 180 top
VR66  [R0805]  191.13,15.88 0 top
VR67  [R0805]  194.94,18.41 180 top
VR68  [R0805]  215.9,15.88 180 top
VR69  [R0805]  209.55,15.88 0 top
VR70  [R0805]  214,18.1 180 top
VR71  [R0805]  234.95,15.88 180 top
VR72  [R0805]  228.6,15.88 0 top
VR73  [R0805]  233.04,18.1 180 top
VR74  [R0805]  254,15.88 180 top
VR75  [R0805]  247.65,15.88 0 top
VR76  [R0805]  252.09,18.1 180 top
VTRIM1  [EVND8AA]  26.35,74.3 90 top
VTRIM2  [EVND8AA]  24.13,15.24 90 top