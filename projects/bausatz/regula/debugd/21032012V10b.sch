# EAGLE board 21032012V10b (EAGLE 5.07)

Size 279.4 x 114.3 mm. Coordinates in mm from the lower left corner, seen from the top.
Outline: 279.4,0 279.4,114.3 0,114.3 0,0 279.4,0
Copper layers (1*16): Top 0.035mm / dielectric 1.5mm / Bottom 0.035mm
Design rules "default *": minimum track width 10mil, minimum drill 24mil, track to track 8mil, track to pad 8mil, pad to pad 8mil, via to via 8mil, smd to smd 8mil, copper to edge 40mil, drill to drill 8mil, minimum pad ring 1mil, minimum via ring 8mil, stop-mask expansion 4mil, vias tented up to drill 0mil, thermal gap 10mil
Holes 2.2 mm at 6.35,5.08 46.99,45.72 6.35,52.7 46.99,5.08 6.35,98.42 46.99,98.42

## Footprints (pad centres in the part's own frame; a part is rotated, then mirrored left to right if it is on the bottom)
TO220ACS = drill 1.016 long: A 2.54,-2.54; C -2.54,-2.54
LED3MM = drill 0.813 octagon: A -1.27,0; K 1.27,0
SMB = smd 2.4 x 2.4: A 2.2,0; C -2.2,0
E5-8,5 = drill 1.016 pad 2.54 round: + -2.54,0 | drill 1.016 pad 2.54 octagon: - 2.54,0
E2,5-6 = drill 0.813 pad 1.6 round: + -1.27,0 | drill 0.813 pad 1.6 octagon: - 1.27,0
E5-6 = drill 0.813 pad 1.905 round: + -2.54,0 | drill 0.813 pad 1.905 octagon: - 2.54,0
C1206 = smd 1.6 x 1.8: 1 -1.4,0; 2 1.4,0
TO247S = drill 1.499 long: 1 -5.588,-2.921; 2 0,-2.921; 3 5.588,-2.921
DPACK = smd 1.6 x 3: 1 -2.28,-4.8; 3 2.28,-4.8 | smd 5.8 x 6.2: 4 0,2.38
SO08 = smd 0.6 x 2.2: 1 -1.905,-2.6; 2 -0.635,-2.6; 3 0.635,-2.6; 4 1.905,-2.6; 5 1.905,2.6; 6 0.635,2.6; 7 -0.635,2.6; 8 -1.905,2.6
317TS = drill 1.016 long: 1 -2.54,-2.54; 2 0,-2.54; 3 2.54,-2.54
MINIMELF = smd 1.4 x 1.8: A 1.7,0; C -1.7,0
SOT23-BEC = smd 1 x 1.4: B -0.95,-1.1; C 0,1.1; E 0.95,-1.1
R5025 = smd 1.8 x 2.7: 1 -2.2,0; 2 2.2,0
R1206 = smd 1.6 x 1.803: 1 -1.422,0; 2 1.422,0
R1210 = smd 1.6 x 2.7: 1 -1.4,0; 2 1.4,0
EVND8AA = drill 1 pad 1.778 long: A -2.5,-2.5; E 2.5,-2.5; S 0.04,2.54
SOT23 = smd 1 x 1.4: 1 -0.95,-1.1; 2 0.95,-1.1; 3 0,1.1
SOD80C = smd 1.4 x 1.8: A 1.7,0; C -1.7,0
SOT223 = smd 1.219 x 2.235: 1 -2.311,-3.099; 2 0,-3.099; 3 2.311,-3.099 | smd 3.6 x 2.2: 4 0,3.099
FUSE_HOLDER_5X20MM = drill 1.422 pad 2.286 square: 1 0,0; 2 15.24,0
DIL8 = drill 0.813 long: 1 -3.81,-3.81; 2 -1.27,-3.81; 3 1.27,-3.81; 4 3.81,-3.81; 5 3.81,3.81; 6 1.27,3.81; 7 -1.27,3.81; 8 -3.81,3.81
TO92S = drill 0.6 pad 0.813 long: 1 -1.27,0; 2 0,0; 3 1.27,0
1X1MM8 = drill 1.6 pad 2.54 octagon: 1 0,0
L5650M = smd 1.8 x 4: 1 -2.5,0; 2 2.5,0
P-LCC-4-3 = smd 3.3 x 4.8: 1 -2,-3.15; 2 -2,3.15; 3 2,3.15; 4 2,-3.15
CHIPLED_1206 = smd 1.5 x 1.5: A 0,-1.75; C 0,1.75
1X4MM5 = drill 4.5 pad 6.35 round: 1 0,0
1X01 = drill 1.016 octagon: 1 0,0
SMD4 = smd 1.78 x 1.55: 1 -1.27,-3.5; 2 1.27,-3.5; 3 1.27,3.5; 4 -1.27,3.5
1X01' = drill 1.016 square: 1 0,0
SOT93V = drill 1.397 long: B -5.461,-2.54; C 0,-2.54; E 5.461,-2.54
TO220AV = drill 1.016 long: B -2.54,-2.54; C 0,-2.54; E 2.54,-2.54
D-PAK_TO252AA = smd 1 x 1.6: 1 -2.28,-4.8; 3 2.28,-4.8 | smd 5.4 x 6.2: 4 0,2.5
TO252 = smd 1 x 1.6: 1 -2.28,-4.8; 2 2.28,-4.8 | smd 5.4 x 6.2: 3 0,2.5
TO126AV = drill 1.016 long: B 2.286,-1.27; C 0,-1.27; E -2.286,-1.27
R2010 = smd 1.8 x 2.7: 1 -2.2,0; 2 2.2,0
CERAM55 = drill 1 pad 2.54 octagon: 1 -22.86,0; 2 22.86,0
0204/7 = drill 0.813 octagon: 1 -3.81,0; 2 3.81,0
CA6V = drill 1.016 long: A -2.54,-2.54; E 2.54,-2.54; S 0,2.54
RANDL = drill 0.9 long: A -4,5; E 4,5; S 0,5 | drill 1 square: P$1 -5,-5; P$2 5,-5
320NEW = drill 1.8 pad 3.81 octagon: 1 -4.928,7.823; 2 -4.928,0; 3 -4.928,-7.823; 4 4.928,7.823; 5 4.928,0; 6 4.928,-7.823
KSS1201 = drill 0.914 pad 2.159 octagon: + 3.251,0; - -3.251,0
S64W = drill 0.7 long: A 2.54,1.27; E -2.54,1.27; S 0,1.27
SOT23-6 = smd 0.635 x 1.27: 1 -1.016,-1.016; 2 0,-1.016; 3 1.016,-1.016; 4 1.016,1.016; 5 0,1.016; 6 -1.016,1.016
TO3-K02 = drill 1.194 pad 3.81 octagon: 1 -1.778,-5.461; 2 -1.778,5.461 | drill 4.115 pad 6.477 round: 3 15.113,0; 3@ -15.113,0
0204V = drill 0.813 octagon: 1 -1.27,0; 2 1.27,0
C050-025X075 = drill 0.813 octagon: 1 -2.54,0; 2 2.54,0
R0402 = smd 0.7 x 0.9: 1 -0.65,0; 2 0.65,0
1X02 = drill 1.016 square: 1 -1.27,0 | drill 1.016 octagon: 2 1.27,0
0207/15 = drill 0.813 octagon: 1 -7.62,0; 2 7.62,0
0204/5 = drill 0.813 octagon: 1 -2.54,0; 2 2.54,0
0617/17 = drill 1.016 octagon: 1 -8.89,0; 2 8.89,0
R0805 = smd 1.3 x 1.5: 1 -0.95,0; 2 0.95,0

## Placement (x,y rotation side)
A  [TO220ACS]  9.84,34.61 270 top
A..C  [LED3MM]  10.79,41.27 180 top
C  [SMB]  8.89,33.97 270 top
C1  [E5-8,5]  32.38,57.78 0 top
C2  [E2,5-6]  33.24,88.84 90 top
C3  [E2,5-6]  24.77,87.63 0 top
C4  [E5-6]  31.75,15.24 270 top
C5  10n  [C1206]  268.61,40.64 90 top
C6  [SMB]  101.6,86.36 0 top
C7  [C1206]  156.84,82.55 270 top
C9  [E5-6]  145.41,90.81 90 top
C10  [E2,5-6]  104.78,93.98 270 top
C-1083  LT1083CP-V  [TO247S]  43.18,26.04 270 top
C-MABDT  LM317MABDT  [DPACK]  25.72,49.53 90 top
C-MABDT1  LM317MABDT  [DPACK]  37.72,82.87 270 top
C-SO1  [SO08]  24.13,60.96 180 top
C-SO8  [SO08]  31.11,35.56 180 top
C-TS  [317TS]  42.8,26.04 270 top
C.  1N4148MINIMELF  [MINIMELF]  8.57,33.97 270 top
C.1  1N4148MINIMELF  [MINIMELF]  37.47,41.27 270 top
CQ3  BC817-40LT1SMD  [SOT23-BEC]  38.54,88.65 90 top
CR1  [R5025]  18.41,38.1 0 top
CR2  [R1206]  27.3,35.56 270 top
CR3  [R1206]  22.54,21.59 90 top
CR4  [R1206]  36.83,45.09 180 top
CR5  [R1210]  24.38,36.07 270 top
CTRIM3  [EVND8AA]  13.92,15.24 90 top
D1  [MINIMELF]  20.95,43.81 180 top
D2  [MINIMELF]  37.91,91.25 0 top
D3  [MINIMELF]  18.73,83.19 180 top
D4  BAS40-04  [SOT23]  12.7,24.13 270 top
D5  [MINIMELF]  15.24,96.52 180 top
D6  [MINIMELF]  34.29,93.34 0 top
D7  [MINIMELF]  30.48,89.53 90 top
D8  [MINIMELF]  85.09,18.1 0 top
D9  [MINIMELF]  91.44,12.7 90 top
D9A  [MINIMELF]  92.08,18.41 0 top
D10  [MINIMELF]  72.39,12.7 90 top
D10A  [MINIMELF]  73.03,18.41 0 top
D10A1  [MINIMELF]  86.36,12.7 270 top
D12  [MINIMELF]  123.83,18.1 180 top
D13  [MINIMELF]  124.46,12.7 90 top
D14  [MINIMELF]  110.49,12.7 90 top
D15  [MINIMELF]  111.12,18.41 0 top
D16  [SOD80C]  268.61,34.92 270 top
D17  [MINIMELF]  104.14,18.1 0 top
D18  [MINIMELF]  105.41,12.7 270 top
D19  [MINIMELF]  163.19,12.06 270 top
D20  [MINIMELF]  161.93,17.78 0 top
D21  [MINIMELF]  201.29,12.7 270 top
D22  [MINIMELF]  200.03,18.41 0 top
D23  [MINIMELF]  238.76,12.06 270 top
D24  [MINIMELF]  238.12,18.1 0 top
D25  [MINIMELF]  150.5,18.41 0 top
D26  [MINIMELF]  149.22,12.06 90 top
D27  [MINIMELF]  188.59,18.41 0 top
D28  [MINIMELF]  186.69,13.97 90 top
D29  [MINIMELF]  225.43,18.41 0 top
D30  [MINIMELF]  224.16,12.7 90 top
D33  [MINIMELF]  142.88,18.1 0 top
D34  [MINIMELF]  144.78,12.7 270 top
D35  [MINIMELF]  129.54,12.7 90 top
D36  [MINIMELF]  130.81,18.41 0 top
D37  [MINIMELF]  182.25,12.7 270 top
D38  [MINIMELF]  180.97,18.41 0 top
D39  [MINIMELF]  220.34,12.7 270 top
D40  [MINIMELF]  218.44,18.1 0 top
D41  [MINIMELF]  258.44,12.06 270 top
D42  [MINIMELF]  257.18,18.1 0 top
D43  [MINIMELF]  169.54,18.41 0 top
D44  [MINIMELF]  167.64,13.34 90 top
D45  [MINIMELF]  207.01,18.41 0 top
D46  [MINIMELF]  205.74,12.7 90 top
D47  [MINIMELF]  244.47,18.41 0 top
D48  [MINIMELF]  243.21,12.06 90 top
DISP_R  [R1206]  123.83,97.79 0 top
DISP_R1  [R1206]  161.29,82.55 90 top
DISP_V  BCX56  [SOT223]  125.09,85.09 0 top
DISP_Z  [MINIMELF]  124.46,94.61 0 top
DISP_Z1  [MINIMELF]  144.78,81.28 270 top
DISP_Z2  [MINIMELF]  142.24,83.82 270 top
DISP_Z3  [MINIMELF]  165.1,82.55 90 top
F1  FUSEBLANK_5X20MM  [FUSE_HOLDER_5X20MM]  8.89,92.71 270 top
IC1  PIC12F675P  [DIL8]  155.57,90.81 0 top
IC2  [TO92S]  31.11,35.56 0 top
JP1  [1X1MM8]  36.2,47.62 0 top
L1  [L5650M]  97.16,93.98 90 top
L2  [L5650M]  90.81,93.98 270 top
LED3  [P-LCC-4-3]  134.62,87.63 0 top
LED4  [CHIPLED_1206]  155.57,22.23 180 top
LED5  [CHIPLED_1206]  194.94,22.23 180 top
LED6  [CHIPLED_1206]  250.82,22.23 180 top
LED7  [CHIPLED_1206]  136.53,22.23 180 top
LED8X  [CHIPLED_1206]  117.47,22.23 180 top
LED9  [CHIPLED_1206]  174.62,22.23 180 top
LED9X  [CHIPLED_1206]  98.42,22.23 180 top
LED10  [CHIPLED_1206]  212.72,22.23 180 top
LED10X  [CHIPLED_1206]  79.38,22.23 180 top
LED11  [CHIPLED_1206]  231.78,22.23 180 top
MINU1S  [1X4MM5]  241.3,5.08 0 top
MINUS0S  [1X4MM5]  260.35,5.08 0 top
MINUS0X1  [1X01]  256.54,6.35 0 top
MINUS1X  [1X01]  236.22,6.99 0 top
MINUS2  [1X4MM5]  222.25,5.08 0 top
MINUS2X1  [1X01]  218.44,3.17 0 top
MINUS3S  [1X4MM5]  203.2,5.08 0 top
MINUS3X  [1X01]  198.12,5.08 0 top
MINUS4S  [1X4MM5]  184.15,5.08 0 top
MINUS4X4  [1X01]  179.07,5.08 0 top
MINUS5S  [1X4MM5]  165.1,5.08 0 top
MINUS5X2  [1X01]  159.38,5.08 0 top
MINUS6S  [1X4MM5]  146.05,5.08 0 top
MINUS6X2  [1X01]  140.34,4.45 0 top
MINUS8  [1X4MM5]  127,5.08 0 top
MINUS8X  [1X01]  119.38,4.45 0 top
MINUS9  [1X4MM5]  107.95,5.08 0 top
MINUS9X1  [1X01]  102.23,4.45 0 top
MINUS10  [1X4MM5]  88.9,5.08 0 top
MINUS10X  [1X01]  83.82,5.08 0 top
MINUS60  [1X4MM5]  256.62,97.08 0 top
MINUS120  [1X4MM5]  218.62,97.08 0 top
OK1X  SFH6186-2  [SMD4]  257.18,24.13 0 top
OK2  SFH6186-2  [SMD4]  74.3,95.25 90 top
OK2X  SFH6186-2  [SMD4]  238.12,24.13 0 top
OK3  SFH6186-2  [SMD4]  219.07,24.13 0 top
OK4X  SFH6186-2  [SMD4]  200.66,24.13 0 top
OK5X  SFH6186-2  [SMD4]  180.97,24.13 0 top
OK6X  SFH6186-2  [SMD4]  162.56,24.13 0 top
OK7  SFH6186-2  [SMD4]  142.88,24.13 0 top
OK8X  SFH6186-2  [SMD4]  123.83,24.13 0 top
OK9X  SFH6186-2  [SMD4]  104.78,24.13 0 top
OK10X  SFH6186-2  [SMD4]  85.72,24.13 0 top
OUT+  [1X01']  7.62,43.18 0 top
PLUS11  [1X4MM5]  69.85,5.08 0 top
PLUS11X  [1X01]  63.5,5.08 0 top
PLUS120  [1X4MM5]  237.62,97.08 0 top
PS_BOT  [C1206]  72.39,90.81 180 top
PS_EMIT  [R1210]  75.56,85.72 0 top
PS_TOP  [C1206]  67.31,90.81 180 top
PS_ZEN_FB  [MINIMELF]  84.45,95.25 270 top
Q1  TIP142SOT93V  [SOT93V]  78.74,41.91 0 top
Q1T  TIP120TO220V  [TO220AV]  78.74,41.91 0 top
Q2  TIP41C  [TO220AV]  21.59,101.6 0 top
Q2S  TIP120  [D-PAK_TO252AA]  97.79,46.99 0 top
Q2T  TIP120TO220V  [TO220AV]  97.79,41.91 0 top
Q3  TIP120  [D-PAK_TO252AA]  116.84,48.26 0 top
Q4  BC807-40SMD  [SOT23-BEC]  269.88,45.72 0 top
Q5  FDD4141TO252  [TO252]  271.78,64.14 0 top
Q6  BC857CSMD  [SOT23-BEC]  85.09,86.36 270 top
Q7  TIP120  [D-PAK_TO252AA]  231.14,48.26 0 top
Q8  TIP120  [D-PAK_TO252AA]  193.04,48.26 0 top
Q9  TIP120  [D-PAK_TO252AA]  154.94,48.26 0 top
Q10  BC857  [SOT223]  92.71,86.36 270 top
Q10S  TIP120  [D-PAK_TO252AA]  78.74,48.26 0 top
Q11  BC847ALT1SMD  [SOT23]  111.12,79.38 0 top
Q12  BD139  [TO126AV]  42.55,38.73 270 top
Q13  BD139  [TO126AV]  42.55,47.62 270 top
Q14  BC857CSMD  [SOT23-BEC]  73.03,25.4 180 top
Q15  TIP120TO220V  [TO220AV]  116.84,41.91 0 top
Q16  TIP120TO220V  [TO220AV]  154.94,41.91 0 top
Q17  TIP120TO220V  [TO220AV]  193.04,41.91 0 top
Q18  TIP120TO220V  [TO220AV]  231.14,41.91 0 top
Q19  BC857CSMD  [SOT23-BEC]  92.08,25.4 180 top
Q20  TIP120  [D-PAK_TO252AA]  135.89,48.26 0 top
Q21  TIP142SOT93V  [SOT93V]  116.84,41.91 0 top
Q22  TIP120TO220V  [TO220AV]  135.89,41.91 0 top
Q23  TIP120  [D-PAK_TO252AA]  250.19,48.26 0 top
Q24  TIP120  [D-PAK_TO252AA]  212.09,48.26 0 top
Q25  TIP120  [D-PAK_TO252AA]  173.99,48.26 0 top
Q26  TIP120TO220V  [TO220AV]  173.99,41.91 0 top
Q27  TIP120TO220V  [TO220AV]  212.09,41.91 0 top
Q28  TIP120TO220V  [TO220AV]  250.19,41.91 0 top
Q29  TIP142SOT93V  [SOT93V]  97.79,41.91 0 top
Q30  BC857CSMD  [SOT23-BEC]  111.76,26.04 180 top
Q31  BC857CSMD  [SOT23-BEC]  131.44,26.04 180 top
Q32  BC857CSMD  [SOT23-BEC]  149.86,26.04 180 top
Q33  BC857CSMD  [SOT23-BEC]  168.91,26.04 180 top
Q34  BC857CSMD  [SOT23-BEC]  187.96,26.04 180 top
Q35  BC857CSMD  [SOT23-BEC]  206.38,26.04 180 top
Q36  BC857CSMD  [SOT23-BEC]  225.43,26.04 180 top
Q37  BC857CSMD  [SOT23-BEC]  244.47,26.04 180 top
Q38  TIP142SOT93V  [SOT93V]  135.89,41.91 0 top
Q39  TIP142SOT93V  [SOT93V]  154.94,41.91 0 top
Q40  TIP142SOT93V  [SOT93V]  173.99,41.91 0 top
Q41  TIP142SOT93V  [SOT93V]  193.04,41.91 0 top
Q42  TIP142SOT93V  [SOT93V]  212.09,41.91 0 top
Q43  TIP142SOT93V  [SOT93V]  231.14,41.91 0 top
Q44  TIP142SOT93V  [SOT93V]  250.19,41.91 0 top
R1  [R2010]  42.04,89.92 90 top
R2  [CERAM55]  78.74,50.16 270 top
R3  [CERAM55]  97.79,50.16 270 top
R4  [CERAM55]  116.84,50.16 270 top
R5  [CERAM55]  135.89,50.16 270 top
R6  0  [0204/7]  271.78,76.2 270 top
R7  270k  [R1206]  271.78,52.7 180 top
R8  180k  [R1206]  267.97,53.98 270 top
R9  120k  [R1206]  272.42,49.53 0 top
R10  33k  [R1206]  272.42,55.88 180 top
R11  14/3m  [R1206]  272.42,33.66 180 top
R12  0.6/200u  [R1206]  272.42,36.83 0 top
R13  [CERAM55]  173.99,50.16 270 top
R14  [CERAM55]  154.94,50.16 270 top
R16  [CERAM55]  193.04,50.16 270 top
R18  [CERAM55]  231.14,50.16 270 top
R19  [CA6V]  150.5,81.92 270 top
R21  [CERAM55]  212.09,50.16 270 top
R22  [RANDL]  11.43,15.24 270 top
R24  [CERAM55]  250.19,50.16 270 top
S1  [320NEW]  186.06,97.79 0 top
SP1  KSS1201  [KSS1201]  166.37,90.53 270 top
T1  BC846  [SOT23]  273.05,41.27 0 top
TO92S  [TO92S]  24.13,60.96 0 top
TRIM0-9  [S64W]  250.82,13.34 180 top
TRIM1-9  [S64W]  231.78,13.34 180 top
TRIM2-7  [S64W]  174.62,13.34 180 top
TRIM2-9  [S64W]  212.09,13.34 180 top
TRIM3-9  [S64W]  193.68,13.34 180 top
TRIM5X  [S64W]  155.57,13.34 180 top
TRIM7X  [S64W]  136.53,13.34 180 top
TRIM8X  [S64W]  117.47,13.34 180 top
TRIM9X  [S64W]  98.42,13.34 180 top
TRIM10X  [S64W]  79.38,13.34 180 top
U$1  BCX56  [SOT223]  111.12,85.72 0 top
U$2  PIC10F204OT  [SOT23-6]  151.76,90.81 180 top
V-1083  LT1083CP-V  [TO247S]  43.18,66.36 270 top
V-TO1  [TO3-K02]  25.04,36.83 225 bottom
V-TO3  [TO3-K02]  25.13,77.11 225 bottom
V-TS  [317TS]  43.18,66.36 270 top
V_C_IN(+)  [1X01]  38.73,47.62 270 top
V_OPTION  [0204V]  19.37,58.55 180 top
VC1  [C050-025X075]  34.29,98.74 0 top
VC2  [C050-025X075]  26.99,95.19 0 top
VC3  [C050-025X075]  19.43,41.15 180 top
VC4  [C1206]  14.61,80.01 180 top
VCBRIDGE1  [R0402]  38.1,50.16 270 top
VENT_RB  [R1206]  98.42,78.74 0 top
VENT_RT  [R1206]  92.71,78.74 0 top
VENTI  [1X02]  114.94,93.98 270 top
VIN(+)  [1X1MM8]  21.59,93.98 270 top
VIN(-)  [1X01']  40.64,96.52 270 top
VIN(-)1  [1X01']  30.48,10.16 270 top
VIN+1  [1X01']  21.59,91.44 270 top
VOUT(+)  [1X01]  6.35,40.64 270 top
VOUT(+)1  [1X01]  237.49,109.86 0 top
VOUT(+)REG  [1X01]  40.64,53.34 270 top
VOUT-  [1X01]  40.64,57.15 180 top
VPOT1  [RANDL]  11.43,62.55 270 top
VPOT2  [S64W]  15.24,62.55 270 top
VR1  390  [0207/15]  21.59,69.53 180 top
VR2  [0204V]  32.38,78.42 180 top
VR3  [0204/5]  28.26,88.96 270 top
VR4  [R1206]  12.06,73.03 0 top
VR5  [R1206]  21.59,66.04 180 top
VR6  [R1206]  20.32,62.23 90 top
VR7  [R1206]  28.26,88.9 270 top
VR8  [R1206]  32.83,76.83 180 top
VR9  [R1206]  20.32,96.52 0 top
VR10  [0617/17]  46.35,83.82 90 top
VR11  [R1206]  74.3,22.23 0 top
VR12  [R1206]  113.03,22.86 0 top
VR13  [R1206]  79.38,8.26 0 top
VR14  [R1206]  81.92,22.86 90 top
VR15  [R0805]  99.06,18.1 180 top
VR16  [R1206]  67.94,95.25 270 top
VR17  [R1206]  132.72,80.01 0 top
VR18  [R1206]  137.79,95.89 0 top
VR19  [R1206]  138.43,80.01 0 top
VR20  [R1206]  132.08,21.59 0 top
VR21  [R1206]  98.42,8.26 0 top
VR22  [R1206]  77.47,90.81 0 top
VR23  [R1206]  80.64,95.25 90 top
VR24  [R1206]  100.97,22.86 90 top
VR25  [R1206]  151.13,22.86 0 top
VR26  [R1206]  189.87,23.5 0 top
VR27  [R1206]  226.69,22.86 180 top
VR28  [R1206]  118.11,8.26 0 top
VR29  [R1206]  120.65,24.13 90 top
VR30  [R1206]  158.75,22.86 90 top
VR31  [R1206]  197.49,22.86 90 top
VR32  [R1206]  234.31,22.86 90 top
VR33  [R1206]  193.68,8.26 0 top
VR34  [R1206]  231.14,8.26 0 top
VR35  [R1206]  155.57,8.26 0 top
VR36  [R1206]  136.53,8.26 0 top
VR37  [R1206]  139.06,23.5 90 top
VR38  [R1206]  170.18,22.23 0 top
VR39  [R1206]  207.65,22.86 0 top
VR40  [R1206]  245.75,22.86 0 top
VR41  [R1206]  177.16,22.23 90 top
VR42  [R1206]  215.26,22.86 90 top
VR43  [R1206]  254,23.5 90 top
VR44  [R1206]  212.72,8.26 0 top
VR45  [R1206]  250.19,8.26 0 top
VR46  [R1206]  174.62,8.26 0 top
VR47  [R0805]  81.92,15.88 180 top
VR48  [R0805]  76.2,15.88 180 top
VR49  [R0805]  80.01,18.1 0 top
VR50  [R0805]  100.97,15.88 180 top
VR51  [R0805]  95.25,15.88 0 top
VR52  [R1206]  93.34,22.23 0 top
VR53  [R0805]  120.65,15.88 180 top
VR54  [R0805]  114.3,15.88 0 top
VR55  [R0805]  118.75,18.1 180 top
VR56  [R0805]  140.34,15.88 180 top
VR57  [R0805]  133.35,15.88 0 top
VR58  [R0805]  138.43,18.41 180 top
VR59  [R0805]  159.38,15.88 180 top
VR60  [R0805]  152.4,15.88 0 top
VR61  [R0805]  156.84,18.41 180 top
VR62  [R0805]  177.16,15.88 0 top
VR63  [R0805]  171.45,15.88 0 top
VR64  [R0805]  174.62,18.41 180 top
VR65  [R0805]  196.85,15.88 180 top
VR66  [R0805]  191.13,15.88 0 top
VR67  [R0805]  194.94,18.41 180 top
VR68  [R0805]  215.26,15.88 180 top
VR69  [R0805]  209.55,15.88 0 top
VR70  [R0805]  212.72,17.78 180 top
VR71  [R0805]  234.95,15.88 180 top
VR72  [R0805]  228.6,15.88 0 top
VR73  [R0805]  231.14,18.1 180 top
VR74  [R0805]  254,15.88 180 top
VR75  [R0805]  247.65,15.88 0 top
VR76  [R0805]  252.09,18.1 180 top
VTRIM1  [EVND8AA]  26.35,74.3 90 top
VTRIM2  [EVND8AA]  24.13,15.24 90 top

## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via)
ADJ2  (via drill 0.6, 1)  (1 unrouted)
  Top 0.406: TO92S.1 22.23,62.23 C-SO1.4 22.23,63.65 VR6.2 v18.41,63.5 VPOT2.S VPOT1.S | 31.55,74.3 33.02,74.93 | V-1083.1 36.17,74.24 35.56,82.23 C-MABDT1.1 | V-TO3.2 19.68,74.3
  Top 1.27: v40.64,74.61 39.37,73.03 | 19.68,74.3 31.55,74.3 | v22.37,76.39 V-TO3.2
  Bottom 0.406: 39.91,72.3 V-1083.1 40.64,71.56 V-TS.1 | 39.91,72.3 39.37,72.83 | 39.91,72.3 40.64,73.03 v40.64,74.61 41.27,74.93 | v18.41,63.5 19.05,64.14
  Bottom 1.27: 19.05,64.14 arc30 22.23,73.66 v22.37,76.39
  pour Bottom (isolate 0.813, hatched): 39.37,76.83 43.18,76.83 43.18,69.22 41.91,67.94 39.37,67.94
  pour Top (isolate 0.813, hatched): 43.18,80.64 43.18,69.22 41.91,67.94 40.64,67.94 39.37,69.22 34.92,73.03 29.21,74.3 34.29,76.2 34.29,78.11 33.34,85.72
ADJUST  (via drill 0.6)  (3 unrouted)
  Top 0.406: 27.53,37.21 CR2.1 | V-TO1.2 19.22,34.29 v17.02,34.29 17.14,33.66 | 29.21,36.83 C-SO8.4 | 29.21,36.83 29.21,36.2 IC2.1 | 9.62,31.68 8.98,31.68 C.A | D4.1 11.12,25.08 10.16,25.4 8.89,29.21 C.A | A.A C..A C.A | 29.21,36.83 28.57,36.83
  Top 1.016: 27.53,37.21 28.57,37.21 28.57,36.83
  Top 1.27: v29.21,28.26 26.67,28.51 arc-90 17.14,33.66 | CR1.1 16.76,36.01 v17.02,34.29
  Bottom 0.406: C-TS.1 40.64,31.24 C-1083.1 39.5,32.38 | A.A 11.11,31.43 v17.02,34.29 | 29.84,33.02 IC2.1
  Bottom 1.27: 29.84,33.02 29.84,29.84 30.29,29.72 | v29.21,28.26 29.53,28.89 30.29,29.72 | 30.29,29.72 arc-37 37.47,31.75 39.37,31.75 C-1083.1
  Bottom 1.778: Q12.E 38.99,41.02 49.53,40.64
  pour Bottom (isolate 0.813, hatched): 19.68,32.38 arc-90 17.78,30.48 7.62,30.48 arc-90 6.35,31.75 6.35,33.66 arc-90 7.62,34.92 10.79,34.92 arc-90 11.43,35.56 19.68,35.56
  pour Top (isolate 0.61): 29.84,39.37 23.5,39.37 23.5,37.47 28.57,36.2 28.57,35.56 29.84,35.56
B
  Top 0.406: VR48.1 78.72,15.9 | VR48.1 78.75,14.59 79.38,13.97 TRIM10X.S | VR48.1 VR47.2 VR49.2 | Q14.B 73.97,25.72 74.3,25.4 74.3,20.32 76.2,20.32 76.2,18.09 VR48.1
B1
  Bottom 0.406: 43.18,8.26 43.18,34.92 42.55,35.56 41.53,35.56 Q12.B
  Bottom 0.61: 43.18,8.26 arc-73 19.68,9.53 13.97,8.89 11.43,11.43 CTRIM3.S R22.S
B-Q1
  Top 0.406: C5.2 268.61,44.3 Q4.B 267.33,46.21 267.33,50.8 267.97,51.44 R8.2
BATT-  (via drill 0.6)  (17 unrouted)
  Top 0.406: VR16.2 67,92.88 66.84,92.88 66.04,92.08 66.04,90.94 PS_TOP.2 65.91,88.39 v66.04,88.27 | v84.45,91.44 PS_ZEN_FB.A | Q11.2 v113.67,80.01 113.67,76.2 88.77,76.2 88.77,29.84 87,27.94 OK10X.3 | v102.23,78.74 VENT_RB.2 | v125.73,92.71 DISP_Z.A | C6.A 107.02,91.25 C10.- | v274.64,45.09 274.95,44.45 274.95,41.27 274,40.32 T1.2 274,36.99 R12.2 | C7.2 155.71,81.15 154.94,81.92 154.94,83.82 154.31,84.45 R19.A
  Top 0.61: IC1.8 U$2.2
  Bottom 0.406: v66.04,88.27 66.04,78.11 67.31,76.2 84.45,76.2 | 118.75,76.2 113.67,76.2 | 113.67,76.2 106.05,76.2 | 106.05,76.2 102.23,76.2 v102.23,78.74 100.33,80.64 90.81,80.64 90.17,80.01 90.17,77.47 88.9,76.2 84.45,76.2 | 84.45,76.2 v84.45,91.44 | 113.67,76.2 v113.67,80.01 | 118.75,76.2 118.75,89.53 121.28,92.71 v125.73,92.71 142.88,92.71 144.15,93.98 145.41,93.98 | C10.- 106.05,89.53 106.05,76.2 | 149.22,94.61 IC1.8 151.76,92.71 152.4,92.08 163.83,92.08 165.53,93.78 SP1.- | 149.22,94.61 149.22,88.27 147.96,87 147.96,85.09 148.59,84.45 R19.A | 145.41,93.98 C9.- | 145.41,93.98 146.05,94.61 149.22,94.61 | 265.43,45.09 v274.64,45.09 | 118.75,76.2 254.63,76.2 255.27,76.83
  Bottom 2.54: S1.5 197.49,97.79 211.46,83.82 255.27,83.82 | 265.43,45.09 265.43,66.04 255.27,76.2 255.27,76.83 255.27,83.82 | MINUS60.1 256.62,95.33 255.27,93.34 255.27,83.82
D  (1 unrouted)
GATE
  Top 0.406: Q5.1 269.5,57.37 R10.2 270.99,55.4 271.78,54.61 271.78,51.44 271.14,50.8 271.14,49.68 R9.1 270.51,49.53 269.88,48.9 Q4.C
IN+1
  Top 0.406: 25.1,82.22 V-TO3.1 31.11,81.28 C-MABDT1.3 | TO92S.3 26.04,62.23 26.04,63.5 C-SO1.1
  Top 0.813: 26.04,59.05 26.04,63.5
  pour Bottom (isolate 0.813, hatched): 43.18,64.14 43.18,59.05 36.07,58.93 37.34,64.01
  pour Top (isolate 0.813, rank 3, hatched): 26.67,100.33 26.67,88.27 30.8,85.72 32.7,78.74 21.59,78.74 18.41,76.83 18.41,71.75 26.04,71.75 29.53,66.74 30.99,62.74 arc90 39.37,64.14 43.18,64.14 43.18,59.05 27.3,59.05 26.04,58.42 26.04,64.14 arc90 22.23,67.94 18.1,68.26 15.24,70.17 15.24,80.01 17.14,81.92 19.68,82.55 arc32 23.5,100.33
  pour Bottom (isolate 0.813, rank 4): 29.21,79.38 22.23,79.38 arc-20 23.5,100.33 26.67,100.33 26.67,87 27.94,85.72 31.75,85.72 31.75,80.64
IN-  (via drill 1.3)
  Top 2.54: v203.84,111.12 v40.64,111.12
  Bottom 0.406: 45.72,92.71 VR10.2 43.18,95.89 VIN(-).1
  Bottom 2.54: MINUS120.1 217.88,97.08 v203.84,111.12 | v40.64,111.12 VIN(-).1
  pour Bottom (isolate 0.813, rank 2): 43.18,99.69 47.62,90.81 35.56,90.81 35.56,99.69
  pour Top (isolate 0.813, hatched): 43.18,100.33 43.18,87.63 38.1,87.63 38.1,92.71 35.56,94.61 35.56,100.33
INPUT+  (via drill 0.6, 1)  (1 unrouted)
  Top 0.406: C-SO8.1 32.7,40.96 v30.48,41.91 V-TO1.1 | C-TS.3 40.64,20.83 C-1083.3 | VC3.1 D1.C | 33.02,35.56 IC2.3 | C-SO8.1 33.02,38.73 | C-SO8.1 33.02,38.1 | v30.48,49.78 C-MABDT.3
  Top 0.813: 33.02,38.1 33.02,35.56 33.02,33.66
  Bottom 0.406: C-1083.3 39.5,19.68 38.73,19.68 34.92,20.32 31.75,21.59 29.21,22.86 25.4,24.13 22.86,26.04 22.23,27.94 24.13,32.38 24.77,38.73 24.13,40.64 24.13,41.27 | v30.48,41.91 26.67,43.81 24.13,41.27 | 33.02,41.27 32.38,41.91 v30.48,41.91 | 24.13,41.27 VC3.1 | v30.48,41.91 v30.48,49.78
  pour Top (isolate 0.813, rank 2, hatched): 27.3,53.34 27.3,45.72 26.04,44.45 21.59,44.45 21.59,40.64 22.86,40.64 23.5,40.01 31.75,40.01 31.75,39.37 32.38,38.73 33.02,38.73 32.38,46.35 37.47,45.72 37.47,43.81 43.18,43.81 43.18,48.9 31.75,53.34
  pour Bottom (isolate 0.813, rank 2, hatched): 43.18,50.8 33.02,52.7 27.94,52.7 28.07,46.35 20.95,41.27 20.95,38.73 22.86,36.83 22.86,34.29 19.68,29.84 6.35,29.84 6.35,24.13 arc16 34.92,19.05 40.64,19.68 40.64,23.5 31.11,23.5 25.4,27.3 26.04,37.47 26.67,38.73 33.66,41.27
MINUS
  Top 0.406: D4.2 13.53,20.13 13.51,13.16 13.97,12.7 16.38,12.7 CTRIM3.A
  Bottom 0.406: R22.E 16.43,12.73 CTRIM3.A
MINUS2  (9 unrouted)
MX4  (10 unrouted)
N$1
  Bottom 0.406: VPOT2.A 16.43,60.01 VPOT1.E 17.27,58.55 V_OPTION.2
N$2
  Top 0.406: VR5.2 16.43,66.04 VPOT1.A 13.34,67.94 arc-135 13.34,71.75 VR4.2
  Bottom 0.813: VPOT2.E 17.78,66.47 VPOT1.A
N$3
  Top 0.406: VTRIM1.E VR8.2
  Bottom 0.813: VTRIM1.E 28.89,76.83
  pour Bottom (isolate 0.813, rank 2, hatched): 32.38,78.11 32.38,76.2 32.07,75.56 31.11,75.56 30.48,74.93 27.3,74.93 26.67,75.56 26.67,78.11
N$4
  Bottom 0.406: VR1.1 28.85,69.53 28.85,71.16
  Bottom 0.813: 28.85,71.16 VTRIM1.A
  pour Bottom (isolate 0.813, rank 3, hatched): 31.75,73.66 31.75,73.03 29.21,70.48 27.3,70.48 26.67,71.12 26.67,73.03 27.3,73.66
N$5
  Bottom 0.406: 17.73,18.41 CTRIM3.E 16.43,17.75 R22.A
  Bottom 0.61: VTRIM2.S 21,17.74 19.68,18.41 17.73,18.41
N$6  (1 unrouted)
  Bottom 0.406: 26.52,9.84 VTRIM2.A
N$7
  Top 0.406: VR7.1 VR3.1
  Bottom 0.406: VR3.1 VC1.1 VC2.2
  pour Bottom (isolate 0.813, rank 3): 34.29,90.81 27.3,90.81 27.3,99.69 34.29,99.69
  pour Top (isolate 0.813, rank 4): 34.29,90.81 27.3,90.81 27.3,100.33 34.29,100.33
N$8  (9 unrouted)
  Bottom 2.54: R5.2 130.81,27.3 129.54,26.04 129.54,7.62 MINUS8.1
N$9  (1 unrouted)
N$10
  Top 0.813: Q2.B 19.05,96.67 VR9.1 D5.C
N$11
  Top 0.406: OK10X.2 87,22.23 86.36,22.86 83.82,22.86 82.55,21.59 82.55,21.44 VR14.1 79.7,20.8 LED10X.C
N$12  (2 unrouted)
  Top 0.406: VR3.2 VR7.2 29.88,87.83 D7.C
  Bottom 0.406: VR3.2 30.42,85.79 31.75,84.45 VR2.1 33.66,74.55 arc-57 23.56,63.63 20.64,61.78 V_OPTION.1
N$13
  Top 0.406: D6.C 31.75,92.08 D7.A
N$14
  Top 0.406: D10A.A 74.72,16.4 VR48.2 75.25,13.65 TRIM10X.A
N$15
  Top 0.406: Q14.C 73.03,22.38 VR11.1
N$16  (1 unrouted)
N$17
  Top 0.406: D10A.C 71.33,15.46 D10.A
N$18
  Top 0.406: T1.3 273.05,46.35 273.69,46.99 273.69,49.38 R9.2
N$19
  Top 0.406: R11.1 273.84,31.9 273.05,31.11 269.24,31.11 268.61,31.75 D16.A
N$20  (2 unrouted)
N$21
  Top 0.406: R11.2 R12.1 270.99,38.58 271.78,39.37 271.78,39.85 T1.1
N$22
  Top 0.406: DISP_V.2 125.09,88.9 125.73,89.53 126.36,89.53 128.91,92.08 128.91,99.06 128.27,99.69 121.96,99.69 121.28,99.01
  Top 0.813: L1.2 97.16,98.42 97.79,99.06 113.67,99.06 | DISP_R.1 122.71,98.91 121.28,99.01 120.65,99.06 113.67,99.06 | 113.67,99.06 VENTI.1
  Bottom 0.406: VENTI.1 C10.+
N$23
  Top 0.406: VR13.2 83.19,8.26 84.45,9.53 84.45,15.24 85.09,15.88 85.09,20 OK10X.1
N$24
  Top 0.406: D8.A 86.79,14.83 D10A1.C
N$25
  Top 0.406: Q1T.B 75.56,36.2 75.72,23.65 VR11.2 76.2,22.23 77.47,20.32 77.47,18.73 VR49.1 | Q1T.B Q1.B | Q1T.B 76.2,42.56 Q10S.1
N$26  (2 unrouted)
N$27  (2 unrouted)
N$29  (1 unrouted)
N$31  (2 unrouted)
N$32  (1 unrouted)
N$33  (4 unrouted)
N$34  (via drill 0.6)
  Top 0.406: LED3.2 131.42,90.78 128.91,88.27 v128.91,87.63
  Top 0.61: C9.+ 145.41,88.9 148.59,87 IC1.1 U$2.5 | v128.91,87.63 128.91,82.22 DISP_V.3
  Bottom 0.61: C9.+ 130.18,88.27 v128.91,87.63
N$35
  Top 0.61: U$2.1 153.42,91.82 154.31,92.71 IC1.7 154.31,95.25 155.57,99.69 169.54,99.69 170.81,97.79 170.81,78.74 167,76.2 135.89,76.2 134.14,78.59 VR17.2
N$36  (via drill 0.6)
  Top 0.61: v141.6,97.79 141.12,97.79 VR18.2 139.7,95.89 139.7,93.98 142.24,91.44 146.69,91.44 147.07,91.82 U$2.3
  Bottom 0.61: IC1.6 156.84,97.79 v141.6,97.79
N$37
  Top 0.406: VR19.2 140.34,79.53 140.34,78.74 141.6,77.47 156.21,77.47 156.84,78.11 157.48,77.47 165.1,77.47 | 165.1,77.47 167,77.47 169.54,80.01 | 165.1,77.47 DISP_Z3.C
  Top 0.61: IC1.5 161.29,97.16 169.54,97.16 169.54,80.01 | U$2.4 147.7,89.79 147.32,90.17 143.51,90.17 139.7,87 139.7,80.49 VR19.2
N$38
  Top 0.813: Q10.3 84.86,84.05 83.82,85.09 83.82,85.24 Q6.E 77.28,85.41 PS_EMIT.2
N$39
  Top 0.406: 89.07,89.11 88.04,89.94 89.53,91.44 | 89.07,89.11 Q10.1 | 89.53,91.44 90.84,91.44 | 90.84,91.44 91.44,91.44 | 90.84,91.44 L2.2 | Q6.B 84.14,87.31 86.36,89.53 88.64,89.53 89.07,89.11 | OK2.3 72.39,96.52 73.66,98.42 86.36,98.42 87,97.16 87,93.34 88.9,91.44 89.53,91.44
N$40
  Top 0.406: Q6.C Q10.2 92.71,86.36 93.34,87 95.25,87 97.16,88.9 L1.1 99.39,90.84 C6.C
N$41
  Top 0.406: OK2.2 80.49,96.52 VR23.2 84.18,96.67 PS_ZEN_FB.C
N$42
  Top 0.406: VR22.2 78.89,91.29 78.74,91.44 78.74,92.08 78.11,92.71 78.11,93.67 OK2.1
N$43  (1 unrouted)
  Top 0.406: 72.39,99.69 88.9,99.69 L2.1 | 68.1,96.52 VR16.1 67.79,96.52 66.04,96.52 64.14,94.61 64.14,85.72 67.31,85.72 68.89,88.58 PS_TOP.1 PS_BOT.2
N$44
  Top 0.813: VENT_RT.2 VENT_RB.1
N$45  (9 unrouted)
  Top 0.406: Q11.1 108.23,77.15 87.63,77.15 87.63,31.75 84.45,27.94 OK10X.4
  Top 0.813: U$1.1 108.81,79 Q11.1
N$46
  Top 0.813: DISP_R.2 123.83,95.25 DISP_Z.C 122.12,89.33 121.28,88.27 121.28,82.22 DISP_V.1
N$47
  Top 0.813: VR17.1 131.29,83.15 LED3.1
N$48
  Top 0.61: VR18.1 136.37,91.03 LED3.3
N$49
  Top 0.813: VR19.1 137.01,84.09 LED3.4
N$50  (4 unrouted)
N$51  (4 unrouted)
N$52  (4 unrouted)
N$53
  Top 0.813: VENTI.2 111.12,88.9 U$1.2 Q11.3
N$55  (1 unrouted)
N$56  (1 unrouted)
N$57  (2 unrouted)
N$59  (10 unrouted)
N$60  (10 unrouted)
N$62  (2 unrouted)
N$63  (2 unrouted)
N$64  (4 unrouted)
N$65  (4 unrouted)
N$66  (2 unrouted)
N$67  (1 unrouted)
N$68  (1 unrouted)
N$69
  Top 0.406: R19.E 144.99,79.38 DISP_Z1.A
N$70  (1 unrouted)
N$71  (1 unrouted)
N$72  (2 unrouted)
N$73  (1 unrouted)
N$74  (1 unrouted)
N$75
  Top 0.406: U$2.6 156.59,89.79 156.84,89.53 IC1.3 C7.1 156.87,83.97 DISP_R1.2 161.57,84.25 DISP_Z3.A
N$76
  Top 0.406: DISP_R1.1 161.29,80.01 160.66,79.38 154.31,79.38 153.67,80.01 153.67,81.28 R19.S
N$77  (2 unrouted)
N$78  (2 unrouted)
N$79  (2 unrouted)
N$80  (1 unrouted)
N$81  (1 unrouted)
N$82  (1 unrouted)
N$83
  Top 0.406: DISP_Z2.A 143.92,82.12 DISP_Z1.C
N$84  (2 unrouted)
N$85  (4 unrouted)
N$86  (4 unrouted)
N$87  (4 unrouted)
N$88  (2 unrouted)
N$89  (1 unrouted)
N$91  (1 unrouted)
N$92  (1 unrouted)
N$93  (4 unrouted)
N$94  (2 unrouted)
N$95  (1 unrouted)
N$96
  Bottom 0.406: SP1.+ 166.37,87.63 164.47,89.53 154.94,89.53 154.31,88.9 IC1.2
N$98  (9 unrouted)
  Bottom 2.54: R14.2 152.4,27.3 149.22,24.13 149.22,8.26 MINUS6S.1
N$99  (1 unrouted)
N$100  (2 unrouted)
N$101  (8 unrouted)
  Bottom 2.54: Q29.E 103.5,39.37 105.41,37.47 105.41,7.62 MINUS9.1 108.58,5.71 108.58,6.35 110.49,8.26 110.49,24.13 113.67,27.3 R4.2
N$102  (4 unrouted)
N$103  (3 unrouted)
N$104  (4 unrouted)
N$105  (4 unrouted)
N$106  (2 unrouted)
N$107  (1 unrouted)
N$108  (2 unrouted)
N$109  (2 unrouted)
N$110  (2 unrouted)
N$111  (4 unrouted)
N$112  (1 unrouted)
N$113  (4 unrouted)
N$114  (2 unrouted)
N$115  (2 unrouted)
N$116  (2 unrouted)
N$117  (10 unrouted)
N$118  (1 unrouted)
N$119  (1 unrouted)
N$120  (1 unrouted)
N$121  (2 unrouted)
N$122  (2 unrouted)
N$123  (2 unrouted)
N$124  (1 unrouted)
N$125  (1 unrouted)
N$126  (1 unrouted)
N$127  (2 unrouted)
N$128
  Top 0.406: TRIM10X.E VR47.1 83.39,16.4 D8.C
N$129  (1 unrouted)
N$130  (1 unrouted)
N$131  (1 unrouted)
N$132  (4 unrouted)
N$133  (1 unrouted)
N$134  (4 unrouted)
N$137  (1 unrouted)
N$140  (1 unrouted)
N$141  (2 unrouted)
N$142  (2 unrouted)
N$143  (4 unrouted)
N$144  (1 unrouted)
N$145  (1 unrouted)
OUT1
  Top 0.406: 33.02,23.44 V-TO1.3 | C-1083.2 35.83,26.04 V-TO1.3 | IC2.2 31.11,34.29 31.75,33.66 C-SO8.7 31.75,31.11 31.43,30.8 | 26.99,32.7 CR2.2 | 31.43,30.8 31.11,30.48 V-TO1.3 | C-MABDT.4 19.05,49.53 D1.A VC3.2 20.32,39.37 CR1.2 22.92,35.37 23.61,34.48 CR5.2 | 31.11,31.11 31.43,31.11 31.43,30.8
  Top 0.813: 30.48,31.11 31.11,31.11 31.11,38.1
  Bottom 0.406: 13.59,41.4 13.34,43.18 13.34,45.09 | A..C.A 13.59,41.4 | IC2.2 31.11,34.23 31.75,33.28 34.23,33.28 34.92,33.97 34.92,37.47 35.56,38.1 Q12.C | 13.59,41.4 VC3.2
  pour Top: 26.67,46.35 19.68,46.35 arc-90 17.78,44.45 arc-64 10.16,45.09 8.89,46.35 6.35,46.35 6.35,52.7 26.67,52.7
  pour Bottom (isolate 0.813, hatched): 41.91,26.67 40.64,26.67 38.1,29.21 38.1,29.84 37.47,30.48 33.02,30.48 36.2,33.02 36.83,33.66 36.83,36.2 38.73,38.1 39.37,38.1 39.37,38.73 36.83,39.37 34.92,39.37 30.54,39.05 26.42,37.78 26.16,26.1 arc33 36.83,22.23 37.47,22.23
  pour Top (isolate 0.813, rank 3, hatched): 10.79,45.09 19.05,45.09 20.32,43.81 20.32,39.37 17.78,39.37 17.78,36.83 20.95,38.73 22.86,37.47 25.4,34.29 31.11,34.29 38.1,27.3 38.1,20.95 34.92,19.05 32.38,14.61 29.21,14.61 28.57,19.05 21.59,23.5 13.34,26.67 10.79,29.21
  pour Bottom (rank 3): 26.67,46.35 19.68,40.01 15.88,36.2 11.43,36.2 11.43,41.91 9.53,45.72 5.71,45.72 5.71,52.7 26.67,52.7
OUT2  (via drill 0.6)
  Top 0.406: 24.13,59.05 24.07,59.05 C-SO1.7 | 24.13,65.41 23.01,65.41 VR5.1 | v39.37,81.92 C-MABDT1.4 | D3.A F1.1
  Top 0.813: 24.13,59.05 TO92S.2 24.13,65.41
  Bottom 0.406: 40.2,66.41 V-1083.2 V-TS.2 | 37.47,77.47 v39.37,81.92 | V-TO3.3 29.84,60.33 27.3,57.78 24.13,57.78 TO92S.2 | F1.1 8.89,93.34
  Bottom 1.27: 14.67,83.82 13.46,85.66 8.89,93.34 | V-1083.2 V-TO3.3 36.2,70.55 37.02,73.91 37.47,77.47
  other vias: 41.27,81.92 41.27,83.82 39.37,83.82
  pour Bottom (isolate 0.813, rank 6, hatched): 38.73,64.14 36.83,62.87 35.56,62.87 35.56,62.23 arc-68 15.88,54.61 arc-90 9.53,61.59 9.53,74.3 11.43,74.93 11.43,81.92 6.35,81.92 6.35,95.25 15.88,95.25 15.88,77.47 14.61,74.93 14.61,57.15 25.08,60.96 27.94,63.18 31.11,66.67 33.02,69.85 36.2,74.3 arc16 35.56,89.22 43.81,89.22 43.81,77.91 38.73,77.79
  pour Top (isolate 0.254, rank 2, hatched): 17.14,81.92 6.35,81.92 6.35,97.16 14.61,97.16 14.61,94.61 17.14,94.61 17.14,88.9
OUT+
  Top 0.406: A.C C..C C.C
  pour Bottom (isolate 0.813, rank 2, hatched): 10.79,36.2 5.71,36.2 5.71,46.35 8.89,45.72 10.79,43.81
PLUS10  (4 unrouted)
  Top 0.406: D10A1.A 86.36,7.62 MINUS10.1
  Top 1.778: Q10S.3 82.29,42.55 Q1.E
  Bottom 0.406: MINUS10X.1 MINUS10.1 89.53,5.08
  Bottom 1.778: Q1.E Q1T.E
  Bottom 2.54: Q1.E 87.63,36.45 87.63,6.35 MINUS10.1 91.44,7.62 91.44,26.04 92.71,27.3 R3.2
PLUS11  (via drill 0.6)  (2 unrouted)
  Top 0.406: LED10X.A 79.38,26.67 R2.2 | Q14.E 71.92,26.5 v71.12,27.94 | D16.C C5.1 269.11,39.24 270.51,40.64 270.51,43.18 271.14,43.81 271.14,44.3 Q4.E 270.82,44.77 271.78,45.72 271.78,46.99 272.42,47.62 272.42,50.8 273.05,51.44 273.05,52.55 R7.1 273.2,53.49 274.32,54.61 274.32,55.4 R10.1 273.84,59.11 | 273.84,59.11 Q5.2 | 273.84,59.11 275.65,59.11 277.5,60.96 277.5,74.93 276.86,75.56 177.8,75.56 v173.99,79.38 | OK2.4 72.39,93.98 73.97,92.39 PS_BOT.1 VR22.1 76.05,89.69 | 76.05,89.69 76.83,88.27 81.28,88.27 81.28,92.71 80.64,93.34 VR23.1 | 74.17,86.36 74.17,88.14 v74.3,88.27 76.05,89.69 | 74.17,86.36 PS_EMIT.1 | VENT_RT.1 76.2,78.74 74.3,81.28 74.17,86.36 | 72.39,8.26 72.39,7.62 PLUS11.1 | 72.39,8.26 D10.C | 72.39,8.26 VR13.1 | DISP_Z2.C 143.94,85.52 v144.15,85.72
  Bottom 0.406: v71.12,27.94 71.12,26.67 72.07,25.72 | v173.99,79.38 173.99,93.34 177.16,96.52 179.86,96.52 S1.2 | v74.3,88.27 74.3,102.23 | v144.15,85.72 127.64,85.72 126.36,87 126.36,89.53 128.91,92.08 128.91,102.23
  Bottom 2.54: R2.2 73.66,27.3 72.07,25.72 71.12,24.77 71.12,6.99 69.85,5.71 PLUS11.1 69.22,4.45 60.33,13.34 60.33,97.16 65.41,102.23 128.91,102.23 175.9,102.23 180.34,97.79 S1.2
Q0C  (2 unrouted)
  pour Bottom (isolate 0.813, hatched): 259.08,74.3 259.08,40.01 241.3,40.01 241.3,74.3
Q1C
  Top 0.406: VR14.2 81.92,25.4 82.55,26.04 82.55,33.02 80.01,35.56 Q1.C
  pour Top (isolate 0.813, hatched): 87.63,74.3 88.27,29.84 69.85,29.84 69.85,74.3
  pour Bottom (isolate 0.813, hatched): 87.63,74.3 87.63,40.01 69.85,40.01 69.85,74.3
Q2C  (2 unrouted)
  pour Bottom (isolate 0.813, hatched): 240.03,74.3 240.03,40.01 222.25,40.01 222.25,74.3
Q3C  (2 unrouted)
  pour Bottom (isolate 0.813, hatched): 220.98,74.3 220.98,40.01 203.2,40.01 203.2,74.3
Q4C  (2 unrouted)
  pour Bottom (isolate 0.813, hatched): 201.93,74.3 201.93,40.01 184.15,40.01 184.15,74.3
Q5C  (2 unrouted)
  pour Bottom (isolate 0.813, hatched): 182.88,74.3 182.88,40.01 165.1,40.01 165.1,74.3
Q6C  (2 unrouted)
  pour Bottom (isolate 0.813, hatched): 163.83,74.3 163.83,40.01 146.05,40.01 146.05,74.3
Q7C  (1 unrouted)
  pour Bottom (isolate 0.813, hatched): 144.78,74.3 144.78,40.01 127,40.01 127,74.3
  pour Top (isolate 0.813, hatched): 144.78,74.3 144.78,40.01 127,40.01 127,74.3
Q8C  (1 unrouted)
  pour Top (isolate 0.813, hatched): 125.73,74.3 125.73,34.92 107.95,34.92 107.95,74.3
  pour Bottom (isolate 0.813, hatched): 125.73,74.93 125.73,40.64 107.95,40.64 107.95,74.93
Q9C  (1 unrouted)
  pour Bottom (isolate 0.813, hatched): 106.68,74.3 106.68,40.01 88.9,40.01 88.9,74.3
  pour Top (isolate 0.813, hatched): 106.68,74.3 106.68,40.01 88.9,40.01 88.9,74.3
V+OUT  (via drill 0.6)
  Top 0.406: 267.33,55.88 267.49,55.88 R8.1 267.97,55.24 269.56,54.23 269.88,53.19 R7.2
  Top 0.61: 267.33,55.88 267.33,71.12 v267.97,72.39
  Bottom 0.61: R6.1 271.14,80.01 | v267.97,72.39 267.97,79.38 268.61,80.01 271.93,80.01 272.22,80.3
  Bottom 1.27: 237.49,107.31 VOUT(+)1.1
  Bottom 2.54: R6.1 272.22,80.3 275.59,82.55 275.59,104.14 269.88,109.86 240.03,109.86 237.49,107.31 237.49,98.42 237.62,98.3 PLUS120.1
V-  (1 unrouted)
  Top 1.778: R1.1 45,87.72 46.35,87 VR10.1 46.35,59.05 43.81,56.52 VOUT-.1 36.2,56.52 C1.-
  Bottom 2.54: S1.4 190.98,109.37 189.23,111.12 53.34,111.12 51.44,109.22 51.44,64.14 44.45,57.15 VOUT-.1
VIN+  (via drill 1.3)
  Top 0.406: VR9.2 21.74,94.13 VIN(+).1
  Top 1.778: 21.59,101.6 Q2.C
  Top 2.54: v189.87,83.82 177.16,83.82 173.99,87 173.99,104.14 171.45,106.68 26.67,106.68 21.59,101.6
  Bottom 0.406: VIN+1.1 VIN(+).1 Q2.C
  Bottom 2.54: S1.6 190.98,84.94 v189.87,83.82
VIRT-  (2 unrouted)
  Top 0.406: D2.C 35.67,92.39 D6.A
  Bottom 0.813: C3.- 26.67,87.63 28.57,89.53 31.11,89.53 31.75,90.17 33.18,90.17 C2.-
VOUT+REG
  Top 0.406: VR4.1 F1.2
  Bottom 2.54: S1.1 178.23,105.61 177.16,106.68 60.96,106.68 55.88,101.6 55.88,62.23 46.99,53.34 VOUT(+)REG.1
  pour Top (isolate 0.813, hatched): 43.18,49.53 39.37,49.53 arc25 33.02,53.98 31.11,54.61 12.7,54.61 arc-73 6.35,66.67 6.35,80.64 13.97,80.64 11.43,67.94 13.34,64.77 13.34,57.78 19.05,57.15 34.92,57.15 43.18,52.07

## Text on the board
Top: MICHAELS | 24112011
Bottom: 14042012 | MICHAELS
tNames: V_in(+) | V_out(+)