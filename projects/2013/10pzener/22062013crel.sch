# EAGLE board 22062013crel (EAGLE 5.07), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via)
ADJ2  (via drill 1)
  Top 0.406: 23.5,69.85 V-SO8.4 23.05,71.27 | VMABDT.1 34.55,92.37 | V-TO3.2 20.95,81.92
  Top 0.813: 23.5,69.85 TO92S.1 | 23.05,71.27 VRB2.2 20.47,71.27 19.68,70.48 18.02,70.48 VPOT1.S | 34.55,92.37 VCAD.+
  Top 1.27: v23.64,84.01 V-TO3.2
  Bottom 0.406: 41.18,79.92 V-1083.1 V-TS.1 | 41.18,79.92 40.64,80.45 | 41.18,79.92 41.91,80.64 v41.91,82.23 42.55,82.55 | V-TO3.2 21.28,81.95 VTRIM1.S 25.12,81.92 VO1.1
  Bottom 0.813: VPOT1.S VPOT2.S 18.73,70.8 19.62,71.06
  Bottom 1.27: 19.62,71.06 arc30 23.5,81.28 v23.64,84.01
  pour Bottom (isolate 0.813, hatched): 40.64,84.45 44.45,84.45 44.45,76.83 43.18,75.56 40.64,75.56
  pour Top (isolate 0.813, hatched): 44.45,85.09 44.45,76.83 43.81,76.2 41.27,76.2 40.64,76.83 arc77 33.66,79.38 24.77,81.92 35.56,83.82 35.56,89.53 34.29,90.81 34.61,95.89 38.1,93.98 38.1,86.36 40.01,85.09
  pour Bottom (isolate 0.813, rank 2): 31.75,94.61 35.56,93.34 35.56,95.89 33.02,95.89
ADJUST  (via drill 0.6, 1)
  Top 0.406: 28.8,44.83 CRLM3.1 | V-TO1.2 20.49,41.91 v18.99,39.69 19.68,38.73 | 30.48,44.45 C-SO8.4 | 30.48,43.18 30.48,44.45 | 10.89,39.3 10.25,39.3 C.A | C.A C..A A.A 7.62,38.73 CDT3L1.A | 30.48,44.45 29.84,44.45 | 30.48,43.18 30.48,41.27 | C-TO92.1 30.48,43.18 | CD4.1 13.06,33.99 12.06,34.92 12.06,37.47 10.79,38.73 10.79,38.76 C.A
  Top 0.61: CQREG.E 41.78,48.9 39.37,48.9 39.1,49.16 CDZHV.A
  Top 0.813: C-1083.1 36.9,42.49 CDZHV.A 34.92,50.16 34.92,52.7 32.76,54.87 CMABDT.1
  Top 1.016: 28.8,44.83 29.84,44.83 29.84,44.45
  Top 1.27: v30.48,35.88 29.59,36.07 arc-33 19.68,38.73
  Bottom 0.406: C-1083.1 40.77,40.01 | 30.99,41.47 C-TO92.1
  Bottom 0.813: 30.99,38.16 30.99,41.47
  Bottom 1.27: C-TS.1 C-1083.1 40.64,39.37 38.73,39.37 arc37 31.18,36.96 30.99,36.77 | v30.48,35.88 30.48,36.26 30.99,36.77 | 30.99,36.77 30.99,38.16
  pour Bottom (isolate 0.813, hatched): 20.95,40.01 arc-90 19.05,38.1 5.71,38.1 5.08,39.37 5.08,41.27 6.35,42.55 12.06,42.55 12.7,43.18 20.95,43.18
  pour Top (isolate 0.61): 31.11,46.99 22.23,46.99 22.23,44.45 29.84,43.81 30.48,43.18 31.11,43.18
B  (via drill 0.6)  (3 unrouted)
  Top 0.406: VR47.2 85.19,24.13 82.3,24.13 80.64,22.48 TRIM10X.S 80.64,21.97 74.93,27.69 72.46,27.69 VR48.1 | VR49.2 80.52,54.68 | v82.3,53.34 82.3,54.21 Q14.B
  Bottom 0.406: 75.69,45.72 75.69,49.78 76.71,50.8 81.28,50.8 82.55,52.07 82.55,53.09 v82.3,53.34 83.06,52.58 83.06,48.77 83.31,47.24
B1
  Bottom 0.406: 43.81,16.51 45.34,17.59 45.34,42.99 43.81,43.81 43.43,43.81 CQREG.B
  Bottom 0.61: 43.81,16.51 34.92,16.51 33.66,15.24 29.21,15.24 27.94,16.51 15.24,16.51 12.7,19.05 CTRIM3.S TRIM3X.S
B2  (via drill 1)
  Top 0.406: U$1.4 81.53,43.18 v82.3,42.67 82.3,42.16 84.07,40.39 84.07,39.05 VR77.2
  Bottom 0.406: v82.3,42.67 82.3,42.93
B-Q1
  Top 0.406: FCB.2 268.61,30.33 FQ1.B 267.33,32.24 267.33,34.29 267.97,34.92 FRBOUT.2
BATT-  (via drill 0.6)  (3 unrouted)
  Top 0.406: v274.64,31.11 274.95,30.48 274.95,27.3 274,26.35 FQHVU.2 274,23.02 FRHVL.2 | DTRIM.A 154.16,92.22 154.31,92.08 156.21,92.08 156.84,91.44 156.84,90.17 157.99,89.53 DCMEAS.2 | OK9X.2 91.44,41.91
  Top 0.61: IC1.8 U$2.2 | DCBLK2.2 148.72,100.84 147.96,101.6 DCBLK1.-
  Top 0.813: PCT1.2 67.31,106.94 67.31,108.71 68.58,109.98 69.06,109.98 PS16.2 | VQ1.2 v115.57,90.93 | PDHOT.A 106.05,104.01 PCOUT.- | VRB.2 104.62,95.86 v103.5,96.77 VDZ1.A | SDL1.A 259.71,12.06 MINUS1-.1 | P_Q2.3 114.71,97.51 115.57,92.08 v115.57,90.93 | DDZ1.A 122.76,88.47 121.28,90.81 115.7,90.81 v115.57,90.93
  Top 1.27: 253.52,62.23 B3.-
  Top 1.422: B1.- 258.13,71.44 256.54,69.85 256.54,64.14 254.63,62.23 253.52,62.23
  Bottom 0.406: 103,90.04 v103.5,96.77 | PCOUT.- 107.31,101.73 | 150.5,102.23 IC1.8 153.03,100.33 153.67,99.69 165.1,99.69 166.8,101.4 SP1.- | 150.5,102.23 150.5,95.89 148.88,94.27 DTRIM.A | 150.5,102.23 147.32,102.23 DCBLK1.- 145.41,101.6 144.15,100.33 | 264.8,31.11 v274.64,31.11
  Bottom 0.813: 264.8,84.45 260.99,84.45 260.35,85.09 180.97,85.09 180.34,84.45 168.91,84.45
  Bottom 1.27: 262.25,10.16 (BATT-).1 | B1.- 261,73.64 261.62,73.03 | 259.08,39.12 259.33,39.37
  Bottom 1.422: Q44.E Q28.E | 261.62,47.62 261.62,73.03
  Bottom 1.778: 259.33,39.37 259.33,39.5 Q44.E
  Bottom 2.54: S1.5 201.29,105.41 212.72,91.44 256.54,91.44 | MINUS60.1 257.89,102.95 256.54,100.97 256.54,91.44 | 256.54,91.44 264.8,84.45 264.8,31.11 264.8,17.14 262.25,10.16 | 262.25,10.16 MINUS1-.1 259.08,15.24 259.08,39.12 | 262.25,10.16 262.25,11.43 261.62,12.06 261.62,47.62
  pour Top (isolate 0.813): 253.37,46.99 257.18,46.99 259.08,44.45 259.08,38.73 254,38.73 253.37,44.45
  pour Bottom (isolate 0.813, rank 2, hatched): 66.04,109.35 66.04,90.55 126.62,90.3 170.43,84.2 172.09,87.63 172.09,106.05 170.18,107.31 68.58,111.89
CVIN
  Top 0.61: CRHV.2 38.63,55.24 C_VIN+.1
  Top 0.813: CQHV.C 42.39,55.4 CRHV.2 38.73,56.03 CO1.2
  Bottom 1.778: C_VIN+.1 CQHV.C
D
  Top 1.27: F2.1B 272.03,58.17 FRFS.2 | FQFET.3 FRFS.2 | FRFS.2 269.49,58.42 F2.1A
E2  (via drill 0.6)
  Top 0.406: 244.47,15.88 SRHOKD.1 | SQ1.E 243.53,35.88 v243.84,36.2 | v248.92,36.2 SLED1.A
  Top 0.813: SDZH1.C 244.47,15.88 244.47,12.7 MINUS2-.1 240.66,12.7 D23.A
  Top 1.27: 250.67,62.23 B3.+ | B4.- 234.47,62.23 235.59,62.23
  Top 1.422: B1.+ 246.7,71.44 247.65,70.48 247.65,64.14 249.56,62.23 250.67,62.23 | 235.59,62.23 237.49,64.14 237.49,69.85 239.08,71.44 B2.-
  Bottom 0.406: 242.57,36.2 v243.84,36.2 v248.92,36.2
  Bottom 1.27: 242.57,73.66 B2.-
  Bottom 1.422: Q43.E Q18.E
  Bottom 1.778: B1.+ 243.21,73.66 242.57,73.03
  Bottom 2.54: MINUS2-.1 PLUS1+.1 242.57,36.2 242.57,73.03 242.57,73.66 | Q43.E 238.12,41.91 240.03,40.01 240.03,11.43 MINUS2-.1 | R24.2 247.17,13.49 MINUS2-.1
  pour Top (isolate 0.813): 234.31,46.99 238.12,46.99 240.03,44.45 239.4,38.73 234.95,38.73 234.31,44.45
E3  (via drill 0.6)
  Top 0.406: 225.43,15.88 VR34.1 | v229.87,36.2 LED6.A
  Top 0.61: Q36.E 224.47,35.88 v224.79,36.2
  Top 0.813: D39.A 221.62,12.06 222.25,10.79 MINUS3-.1 225.43,10.79 225.43,15.88 D30.C
  Top 1.27: B6.- 215.42,62.23 216.53,62.23
  Top 1.422: 216.53,62.23 218.44,64.14 218.44,69.85 220.09,71.5 220.03,71.56 B5.- | B4.+ 231.62,62.23 230.5,62.23 228.6,64.14 228.6,70.48 227.65,71.44 B2.+
  Bottom 0.406: v224.79,36.2 v229.87,36.2
  Bottom 0.61: v224.79,36.2 224.16,36.2 | PLUS2+.1 223.2,15.56
  Bottom 1.27: MINUS3-.1 PLUS2+.1 224.16,12.06 224.16,36.2 224.16,73.66 B2.+
  Bottom 1.422: Q42.E Q27.E | MINUS3-.1 223.52,15.24 223.2,15.56 222.88,13.97 222.88,73.66 B5.-
  Bottom 1.778: 220.98,40.01 220.73,40.01 Q42.E
  Bottom 2.54: 220.98,40.01 220.98,15.24 MINUS3-.1 228.12,13.49 R18.2
  pour Top (isolate 0.813): 215.26,46.99 219.07,46.99 220.98,44.45 220.34,38.73 215.9,38.73 215.26,44.45
E4  (via drill 0.6)
  Top 0.406: v210.82,36.2 LED10.A | 206.38,15.88 VR44.1
  Top 0.61: Q35.E 205.43,35.88 v205.74,36.2
  Top 0.813: D46.C 207.01,18.41 206.38,17.78 206.38,15.88 206.38,12.06 MINUS4-.1 202.56,12.7 D21.A
  Top 1.27: B8.- 196.37,62.23 197.49,62.23
  Top 1.422: 197.49,62.23 199.39,64.14 199.39,69.85 200.98,71.44 B7.- | B6.+ 212.57,62.23 211.46,62.23 209.55,64.14 209.55,70.48 208.6,71.44 B5.+
  Bottom 0.406: 204.47,13.34 205.1,12.06 | v205.74,36.2 v210.82,36.2
  Bottom 0.61: 205.1,36.2 v205.74,36.2
  Bottom 1.27: MINUS4-.1 204.47,13.34 PLUS3+.1
  Bottom 1.422: Q41.E Q17.E | B5.+ 205.1,73.66 205.1,36.2 205.1,12.06 | 203.84,12.7 203.84,73.66 B7.-
  Bottom 1.778: 201.93,40.01 201.68,40.01 Q41.E
  Bottom 2.54: 201.93,40.01 201.93,11.43 203.84,9.53 203.84,12.7 MINUS4-.1 209.07,13.49 R21.2
  pour Top (isolate 0.813): 196.22,46.99 200.03,46.99 201.93,44.45 201.29,38.73 196.85,38.73 196.22,44.45
E5  (via drill 0.6)
  Top 0.406: 185.42,12.06 185.42,11.43 MINUS5-.1 | v192.41,36.2 LED5.A | Q34.E 186.37,35.71 v186.69,36.2 | 187.32,15.88 VR33.1
  Top 0.813: 185.42,12.06 187.32,13.65 187.32,15.88 D28.C | D37.A 183.51,13.34 185.42,11.43
  Top 1.27: B9.- 181.93,71.44 | 189.55,71.44 B7.+
  Top 1.422: 181.93,71.44 180.34,69.85 180.34,64.14 178.44,62.23 178.31,62.35 B10.- | B8.+ 193.52,62.23 192.41,62.23 190.5,64.14 190.5,70.48 189.55,71.44
  Bottom 0.406: v192.41,36.2 v186.69,36.2 185.42,36.2
  Bottom 1.27: MINUS5-.1 185.42,10.16 PLUS4+.1
  Bottom 1.422: Q40.E Q26.E
  Bottom 1.778: 182.88,40.01 182.63,40.01 Q40.E
  Bottom 2.54: 182.88,40.01 182.88,15.24 MINUS5-.1 190.02,13.49 R16.2 | B9.- 184.78,73.66 185.42,73.03 | 185.42,73.03 185.42,36.2 185.42,10.16 | 185.42,73.03 186.06,73.66 B7.+
  pour Top (isolate 0.813): 177.16,46.99 180.97,46.99 182.88,44.45 182.25,38.73 177.8,38.73 177.16,44.45
E6  (via drill 0.6)
  Top 0.406: v173.35,36.2 LED9.A
  Top 0.61: 168.28,15.88 VR46.1 | Q33.E 168.59,35.88 v168.28,36.2 | 164.47,11.43 165.1,10.16 MINUS6-.1
  Top 0.813: D44.C 168.28,15.88 168.28,12.7 MINUS6-.1 | 164.47,11.43 D19.A
  Top 1.422: B12.- 158.27,62.23 159.38,62.23 161.29,64.14 161.29,69.85 162.88,71.44 B11.- | B10.+ 174.47,62.23 173.35,62.23 171.45,64.14 171.45,70.48 170.5,71.44 B9.+
  Bottom 0.406: v168.28,36.2 v173.35,36.2
  Bottom 0.61: 167,36.2 v168.28,36.2 | PLUS5+.1 167,11.43
  Bottom 1.27: MINUS6-.1 PLUS5+.1
  Bottom 1.422: Q39.E Q16.E | B9.+ 167,73.66 167,36.2 167,11.43 165.74,13.97 165.74,73.66 B11.-
  Bottom 1.778: 163.83,40.01 163.58,40.01 Q39.E
  Bottom 2.54: 163.83,40.01 163.83,15.24 MINUS6-.1 170.97,13.49 R13.2
  pour Top (isolate 0.813): 158.12,46.99 161.93,46.99 163.83,44.45 163.19,38.73 158.75,38.73 158.12,44.45
E7  (via drill 0.6)
  Top 0.406: 149.22,15.88 VR35.1 | v154.31,36.2 LED4.A
  Top 0.61: Q32.E 148.28,35.88 v148.59,36.2 | 146.05,9.53 MINUS7-.1
  Top 0.813: D34.A 145.41,11.43 146.05,9.53 | D26.C 149.22,15.88 149.22,11.43 MINUS7-.1
  Top 1.422: B12.+ 155.42,62.23 154.31,62.23 152.4,64.14 152.4,70.48 151.45,71.44 B11.+
  Bottom 0.406: v148.59,36.2 v154.31,36.2
  Bottom 0.61: 147.96,35.56 v148.59,36.2
  Bottom 1.27: MINUS7-.1 PLUS6+.1
  Bottom 1.422: Q38.E Q22.E | B11.+ 147.96,73.66 147.96,35.56 147.96,12.06 PLUS6+.1 146.69,14.61 146.69,73.66
  Bottom 1.778: 144.78,40.01 144.53,40.01 Q38.E
  Bottom 2.54: 144.78,40.01 144.78,15.24 MINUS7-.1 151.92,13.49 R14.2
  pour Top (isolate 0.813): 139.06,46.99 142.88,46.99 144.78,44.45 144.15,38.73 139.7,38.73 139.06,44.45
E8  (via drill 0.6)  (4 unrouted)
  Top 0.406: 130.18,15.88 VR36.1 | v134.62,36.2 LED7.A
  Top 0.61: Q31.E 129.22,35.88 v129.54,36.2 | 126.36,11.43 127.64,10.16 MINUS8-.1
  Top 0.813: 126.36,11.43 D13.C | D35.C 130.18,15.88 130.18,11.43 MINUS8-.1
  Bottom 0.406: v129.54,36.2 v134.62,36.2
  Bottom 0.61: 128.91,36.2 v129.54,36.2 | 126.36,12.7 127.25,15.49 128.14,15.49
  Bottom 1.27: MINUS8-.1 PLUS7+.1
  Bottom 1.422: 128.91,73.66 128.91,36.2 128.91,11.43 128.14,15.49 127.64,13.34 127.64,73.66
  Bottom 1.778: Q15.E Q21.E 125.48,40.01 125.73,40.01
  Bottom 2.54: 125.73,40.01 125.73,14.61 126.36,12.7 MINUS8-.1 132.87,13.49 R5.2
  pour Top (isolate 0.813): 120.02,46.99 123.83,46.99 125.73,44.45 125.09,38.73 120.65,38.73 120.02,44.45
E9  (via drill 0.6)  (1 unrouted)
  Top 0.406: 111.12,15.88 VR28.1 | v115.57,36.2 LED8X.A | Q2S.3 104.52,58.49 K2.P
  Top 0.61: Q30.E 110.17,35.88 v110.49,36.2 | MINUS9-.1 107.31,10.16
  Top 0.813: D14.C 111.12,15.88 111.12,11.43 MINUS9-.1
  Top 1.27: Q29.E Q2T.E
  Bottom 0.406: v110.49,36.2 v115.57,36.2 | 109.86,73.66 108.58,73.66
  Bottom 0.61: 109.86,36.2 v110.49,36.2 | 109.86,13.97 PLUS8+.1
  Bottom 1.27: 102.62,46.99 Q29.E 106.05,46.23 106.05,43.69
  Bottom 1.422: 109.86,13.97 109.86,36.2 109.86,73.66 | 108.58,73.66 108.58,57.15 108.58,11.43
  Bottom 1.778: 109.86,9.53 109.86,13.97
  Bottom 2.54: 106.05,43.69 106.68,40.01 106.68,11.43 MINUS9-.1 | R4.2 113.82,13.49 MINUS9-.1 | MINUS9-.1 109.86,9.53 | K2.P 109.17,56.84 109.22,56.9 108.84,56.9 108.58,57.15
E10  (via drill 0.5)  (8 unrouted)
  Top 0.406: K2.1 99.19,76.83 102.11,79.76 102.11,80.44 D9A.C | VR18.2 88.9,10.92 MINUS10.1 | D10A1.A 87.45,26.49 v87.12,26.16 | VR23.2 87.7,32.58 v87.38,32.26
  Top 0.813: MINUS10.1 92.08,11.43 92.08,15.88 D9.C
  Top 1.676: Q10S.3 84.32,70.94 K1.P
  Bottom 0.406: K2.1 91.06,76.83 89.66,75.44 | 89.41,17.02 89.41,9.65 MINUS10.1 | 89.41,26.16 v87.12,26.16 | v87.38,32.26 89.15,32.26 89.41,32.51
  Bottom 0.61: SP3.- 89.15,29.46 89.41,29.21
  Bottom 1.676: PLUS9+.1 90.17,16.26 89.41,17.02 89.41,26.16 89.41,29.21 89.41,32.51 89.41,59.44 | 89.41,59.44 89.41,59.69 88.65,60.45 Q1.E | K1.P 88.32,70.69 88.9,70.1 88.9,59.94 89.41,59.44
GATE
  Top 0.406: FQFET.1 269.5,43.4 FRGS.2 270.99,41.43 271.78,40.64 271.78,37.47 271.14,36.83 271.14,35.71 FRGTE.1 270.51,35.56 269.88,34.92 FQ1.C
GP3  (5 unrouted)
  Bottom 0.406: SP3.+ 77.72,29.67
HOT  (via drill 0.6)
  Top 0.813: PQ2.C PQ1.2 93.98,102.36 94.61,103 96.52,103 98.42,104.9 v98.42,105.54 P_L1.1 100.67,105.58 PDHOT.C
  pour Top (isolate 0.813, hatched): 96.52,108.08 100.33,108.08 101.6,106.81 101.6,100.46 100.97,99.82 95.25,99.82 93.34,101.73 92.08,101.73 92.08,103 93.98,103 95.89,104.9 95.89,105.54 96.52,106.17
  pour Bottom (isolate 0.813, hatched): 96.52,104.27 100.33,104.27 101.6,103 101.6,92.08 100.97,91.44 98.81,92.2 93.34,97.92 92.08,97.92 92.08,99.19 93.98,99.19 95.89,101.09 95.89,101.73 96.52,102.36
IN+1  (3 unrouted)
  Top 0.406: 26.37,89.84 V-TO3.1 32.38,88.9 VMABDT.3 | TO92S.3 27.3,69.85 27.3,71.12 V-SO8.1
  Top 0.813: 27.3,66.67 27.3,71.12
  pour Bottom (isolate 0.813, hatched): 44.45,71.75 44.45,66.67 37.34,66.55 38.61,71.63
  pour Top (isolate 0.813, rank 3, hatched): 27.3,107.95 27.3,95.89 32.07,93.34 33.97,86.36 22.86,86.36 19.68,84.45 19.68,79.38 27.3,79.38 30.8,74.36 31.62,73.53 arc139 41.91,71.75 44.45,71.75 44.45,66.67 28.57,66.67 27.3,66.04 27.3,71.75 arc90 23.5,75.56 19.37,75.88 16.51,77.79 16.51,87.63 18.41,89.53 21.78,89.66 21.97,96.9 23.5,97.16 24.77,107.95
  pour Bottom (isolate 0.813, rank 4): 30.48,87 17.14,87 17.21,88.2 21.46,91.06 21.59,92.71 21.59,97.16 24.77,108.58 27.94,108.58 27.94,94.61 29.21,93.34 33.02,93.34 33.02,88.27
IN-  (via drill 1.3)
  Top 0.406: VCQ.E 40.63,96.96 | VR-B.2 41.3,99.74 VD2.A
  Top 0.813: 40.63,96.96 VD2.A
  Top 2.54: v205.1,122.56 v41.91,122.56
  Bottom 0.406: 46.99,100.33 VRSHNT.2 44.45,103.5 VIN(-).1
  Bottom 2.54: MINUS120.1 219.15,104.7 v205.1,122.56 | v41.91,122.56 VIN(-).1
  pour Bottom (isolate 0.813, rank 2): 36.83,108.58 47.62,108.58 48.9,106.05 48.9,98.42 36.83,98.42
  pour Top (isolate 0.813, rank 2, hatched): 48.9,107.95 48.9,98.42 39.37,98.42 39.37,102.23 36.83,102.23 36.83,107.95
INPUT+  (via drill 1)
  Top 0.406: C-SO8.1 33.97,48.58 v31.81,49.53 V-TO1.1 | CCIO1.1 CDZIO.C | 34.29,43.18 C-TO92.3 | C-SO8.1 34.29,46.35 | 34.29,45.72 C-SO8.1 | v31.75,57.4 CMABDT.3
  Top 0.61: 38.73,59.05 CO1.1
  Top 0.813: 34.29,45.72 34.29,43.18 34.29,41.27 | CQHV.E 38.73,59.05
  Bottom 1.27: C-1083.3 C-TS.3
  pour Top (isolate 0.61, rank 2, hatched): 34.92,60.33 27.94,60.33 27.3,52.07 22.86,52.07 22.86,48.26 24.13,48.26 24.77,47.62 33.02,47.62 33.02,46.99 34.92,46.99
  pour Bottom (isolate 0.813, rank 2, hatched): 44.45,58.42 34.29,60.33 29.21,60.33 29.21,53.98 22.23,48.9 22.23,46.35 24.13,44.45 24.13,41.91 22.23,38.73 22.23,27.94 31.11,27.94 38.73,24.13 42.55,24.13 42.55,31.11 32.38,31.11 26.67,34.92 26.67,45.09 27.94,46.35 34.92,48.9 34.92,55.88 44.45,56.52
  pour Top (isolate 0.813, rank 2): 39.37,27.94 43.81,27.94 43.81,15.88 39.37,15.88
MINUS
  Top 0.406: CTRIM3.A 17.65,20.32 10.16,20.32 9.7,20.79 9.72,27.75 9.72,30.67 10.16,31.11 CDT3L2.C 10.59,32.59 10.79,32.38 10.64,32.38 CD4.2
  Bottom 0.406: TRIM3X.E CTRIM3.A
N$1
  Bottom 0.406: 17.7,67.63 VPOT2.A | VPOT1.E 17.78,65.98
  Bottom 1.016: VPOT1.E 17.7,67.63
  Bottom 1.27: 17.78,65.98 VO2.2
N$2
  Top 0.406: VRT2.2 17.7,73.66 VPOT1.A 15.43,74.8 arc-135 14.61,79.38 VRT3.2
  Bottom 0.813: 17.72,74.02 VPOT1.A
  Bottom 1.27: VPOT2.E 17.72,74.02
N$3
  Top 0.406: VTRIM1.E VRB1.2
  Bottom 0.813: VTRIM1.E 30.16,84.45
  pour Bottom (isolate 0.813, rank 2, hatched): 33.66,85.72 33.66,83.82 34.61,82.55 28.57,82.55 27.94,83.19 27.94,85.72
N$4
  Bottom 0.406: VRT1.1 30.12,77.15 30.12,78.78 | VTRIM1.A 27.73,79.42 VO1.2
  Bottom 0.813: VTRIM1.A 30.12,78.78
  pour Bottom (isolate 0.813, rank 3, hatched): 33.66,81.28 32.38,76.83 30.48,74.93 27.94,75.56 27.94,80.64 28.57,81.28
N$5
  Bottom 0.406: 19,26.04 CTRIM3.E TRIM3X.A
  Bottom 0.61: 22.27,25.36 20.95,26.04 19,26.04
  Bottom 0.813: CTRIM2.A 25.4,20.36 CTRIM2.S 22.86,24.77 22.27,25.36
N$6
  Top 0.813: CRT2H.1 25.47,27.79 CTRIM2.E
N$7
  Top 0.406: VR3X.1 VR3.1
  Bottom 0.406: VR3.1 VCLO.1 VCHI.2
  pour Bottom (isolate 0.813, rank 3): 35.56,98.42 28.57,98.42 28.57,108.58 35.56,108.58
  pour Top (isolate 0.813, rank 4): 35.56,98.42 28.57,98.42 28.57,107.95 35.56,107.95
N$8
  Top 1.27: B3.~1 253.4,71.15 254,71.75 254,73.34 B1.AC1
  Bottom 1.27: B1.AC1 254.32,75.88 JP1.1
N$9
  Bottom 0.813: CCOUT.- 33.02,19.05 VIN(-)1.1
  pour Bottom (isolate 0.813): 29.84,22.23 38.73,22.23 38.73,17.14 34.92,17.14 33.66,15.88 30.48,15.88 29.84,16.51
  pour Top (isolate 0.813): 29.84,22.23 38.73,22.23 38.73,15.88 30.48,15.88 29.84,16.51
N$10
  Top 0.813: VQHV.B 20.32,104.29 VRHV.1
  Top 1.27: VZDHV.C 20.32,106.3 VQHV.B
N$11
  Top 0.406: VR14.1 76.71,52.58 78.49,50.8 79.76,49.11 LED10X.C
N$12
  Top 0.406: VR3.2 VR3X.2
  Top 0.813: VD-S2.C 31.15,95.45 VR3X.2 | VR8X.1 VRB1.1 | VO2.1 VRB2.1
  Bottom 0.813: 34.92,84.09 arc-77 23.56,70.67 23.05,70.67 21.4,68.83 VO2.1
  Bottom 1.27: VR3.2 31.69,93.41 34.92,92.08 VR8X.1 34.92,84.09
N$13
  Top 0.813: VD-S1.C 33.02,100.97 VD-S2.A
N$14
  Top 0.406: D10A.A 72.39,23.73 VR48.2 72.58,25.91 75.18,25.91 78.11,22.99 TRIM10X.A
N$15  (2 unrouted)
  Top 0.406: D10A2.C 73.61,92.5 75.18,90.93 76.33,90.93 K1.1
  Top 0.61: Q14.C 84.98,57.04 87.88,58.93 87.88,87.38 87.12,88.14 79.12,88.14 K1.1
N$16
  Top 0.406: VR28.2 123.19,15.88 124.46,17.14 124.46,22.86 125.09,23.5 125.09,26.98 OK8X.1
N$17
  Top 0.406: VR2.2 72.92,20.8 D10A.C 72.39,20.27 72.39,19.56 73.23,18.72 D10.A 78.11,14.85 TRIM10X1.A
N$18
  Top 0.406: FQHVU.3 273.05,32.38 273.69,33.02 273.69,35.41 FRGTE.2
N$19
  Top 0.406: FRHVT.1 273.84,17.93 273.05,17.14 269.24,17.14 268.61,17.78 FDZHV.A
N$20
  Top 0.406: D9.A 95.58,21.26 95.76,21.08 | 95.76,21.08 TRIM9X.A 97.03,19.81 97.03,21.08 97.66,22.48 VR51.1 | VR5.1 95.82,21.14 95.76,21.08
N$21
  Top 0.406: FRHVT.2 FRHVL.1 270.99,24.61 271.78,25.4 271.78,25.89 FQHVU.1
N$22  (1 unrouted)
  Top 0.406: TRIM10X1.S 80.64,14.86 75.95,19.56 75.95,22.35 74.7,22.35 VR2.1 | VR78.2 78.23,36.32 78.74,36.83 79.5,36.83 VR79.2
N$23  (1 unrouted)
N$24
  Top 0.406: TRIM10X1.E 83.19,15.37 84.33,16.26 84.99,15.6 VR19.1
N$25  (4 unrouted)
N$26
  Top 0.406: D15.A 114.09,24.02 VR54.1
  Top 0.813: VR54.1 114.62,21.27 TRIM8X.A
N$27
  Top 0.406: 122.56,23.18 VR53.1 122.87,25.19 D12.A
  Top 0.813: TRIM8X.E 122.56,20.95 122.56,23.18
N$29
  Top 0.813: D15.C 110.69,23.09 D14.A
N$31
  Top 0.406: LED8X.C 119.53,33.81 120.02,34.29 121.13,34.29 VR29.1 121.77,33.66 121.92,33.66 124.46,31.11 125.73,31.11 126.36,30.48 OK8X.2
N$32  (2 unrouted)
  Top 0.406: 127,25.51 D12.C
  Top 0.813: D13.A 126.36,22.86 127,23.5 127,25.51
N$33
  Top 0.406: Q15.B 114.3,41.91 113.67,41.27 113.67,30.33 VR12.2 114.45,29.21 114.94,29.21 118.43,25.72 VR55.2
  Top 0.61: Q3.1 115.83,44.71 115.57,44.45 Q15.B
  Top 1.27: Q15.B Q21.B
  Bottom 1.27: Q15.B 113.03,41.91
N$34  (via drill 0.6)
  Top 0.406: DLED.2 133.32,101.58
  Top 0.61: DCBLK1.+ 147.96,94.61 148.59,94.61 | 148.59,94.61 IC1.1 U$2.5 | v132.72,105.41 132.08,105.72 | DCBLK2.1 148.72,94.74 148.59,94.61
  Top 0.813: 132.08,105.72 DQ1.3 | 133.32,101.58 133.35,104.14 v132.72,105.41
  Bottom 0.813: DCBLK1.+ 140.97,96.52 v132.72,105.41
N$35  (via drill 0.6)
  Top 0.406: DRRED.2 135.41,86.21 135.89,85.53 168.28,85.53
  Top 0.61: U$2.1 154.69,99.44 155.57,100.33 IC1.7 | 168.28,85.53 168.28,85.66 170.18,87.57 170.5,89.53 170.5,96.58
  Top 0.813: 170.5,96.58 170.5,104.78 v163.19,104.78
  Bottom 0.406: v163.19,104.78 156.21,104.78 155.57,104.14 IC1.7
N$36
  Top 0.406: IC1.6 158.12,104.14 157.48,104.78 150.5,104.78 | 141.12,104.78 DRBLU.2 | U$2.3 151.38,99.44 150.5,100.33
  Top 0.813: 141.12,104.78 150.5,104.78 150.5,100.33
N$37  (via drill 0.6)
  Top 0.406: 147.07,97.41 U$2.4 | v142.88,87 141.76,87 DRGRN.2
  Top 0.61: 147.07,97.41 146.05,99.06 142.88,99.06 140.97,97.16 140.97,88.11 DRGRN.2
  Top 0.813: DDMEAS.C 167.21,87.83 v168.28,88.9
  Bottom 0.406: IC1.5 164.47,102.23 165.74,103.5 170.18,103.5 170.5,102.87 170.5,88.9 170.18,87.63 | 170.18,87.63 168.28,85.72 143.51,85.72 v142.88,87 | v168.28,88.9 168.91,88.9 170.18,87.63
N$38
  Top 0.813: PQ1.3 86.13,100.05 85.09,101.09 85.09,101.24 PQ2.E 78.55,101.41 PRE.2
N$39
  Top 0.61: 73.66,112.52 74.93,114.43 87.63,114.43 88.27,113.16
  Top 0.813: 92.11,107.44 92.71,107.44 | 92.11,107.44 L2.2 92.03,107.44 | PSOK2.3 73.66,112.52 | PQ2.B 85.26,104.44 85.72,104.9 88.9,104.9 | 88.9,104.9 90.65,104.9 PQ1.1 | 88.27,113.16 88.27,108.08 88.9,107.44 | 88.9,107.44 92.03,107.44 | 92.03,107.44 92.11,107.44 | 88.9,107.44 88.9,104.9
N$40
  Top 1.27: B1.AC2 250.51,71.44 250.82,71.12 250.82,69.75 B3.~2
  Bottom 1.422: JP2.1 250.19,73.98 B1.AC2
N$41
  Top 0.813: PSOK2.2 81.76,112.52 PSR23.2 85.45,112.67 PZDFB.C
N$42
  Top 0.813: PSR22.2 80.16,107.29 80.01,107.44 80.01,108.08 79.38,108.71 79.38,109.67 PSOK2.1
N$43
  Top 0.813: L2.1 90.17,115.7 72.24,115.7 PS16.1 | PS16.1 69.37,112.52 | PS16.1 69.06,112.52 67.31,112.52 65.41,110.62 65.41,101.73 68.58,101.73 69.97,103.12 PCT1.1 PCB.2
N$45
  Top 0.406: Q35.C 206.22,31.77 VR39.1
N$46
  Top 0.61: DDZ1.C 126.16,103.35 DRTOP.2 126.69,103.63 DQ1.1
N$47
  Top 0.813: DRRED.1 132.56,90.77 DLED.1
N$48
  Top 0.61: 137.64,98.65 DLED.3
  Top 0.813: 137.64,98.65 DRBLU.1
N$49
  Top 0.813: DRGRN.1 138.28,91.71 DLED.4
N$50
  Top 0.406: Q16.B 151.76,41.91 151.76,30.48 152.4,30.33 VR25.2 152.55,29.21 153.03,29.21 156.53,25.72 VR61.2
  Top 0.61: Q9.1 153.93,44.71 153.67,44.45 Q16.B
  Top 1.27: Q16.B Q39.B
  Bottom 1.27: Q16.B 151.13,41.91
N$51
  Top 0.406: Q17.B 190.5,41.91 189.87,41.27 189.87,31.11 VR26.2 190.65,29.21 191.13,29.21 194.63,25.72 VR67.2
  Top 0.61: Q8.1 192.03,44.71 191.77,44.45 Q17.B
  Top 1.27: Q17.B Q41.B
  Bottom 1.27: Q17.B 189.23,41.91
N$52
  Top 0.406: 227.97,41.91 227.97,31.75 228.12,31.6 VR27.1 228.75,29.21 229.24,29.21 232.73,25.72 VR73.2
  Top 0.61: Q7.1 230.13,44.71 229.87,44.45 Q18.B
  Top 1.27: Q18.B 227.97,41.91 Q43.B
  Bottom 1.27: Q18.B 227.33,41.91
N$53
  Top 0.813: VENTILATOR.2 112.39,104.9 P_Q2.2 VQ1.3
N$54
  Top 0.406: CDT3L1.C 7.62,33.02 8.26,33.02 9.53,35.35 CDT3L2.A
N$55
  Top 0.813: D34.C 145.84,22.23 D33.A
N$56  (via drill 0.6)
  Top 0.406: v100.33,27.94 U$7.2 | D9A1.A 93.73,32.26 v93.47,33.78 92.2,33.78 91.44,34.54 OK9X.3 92.4,37.34 101.35,37.34 101.41,37.15 C1.2 102.55,35.56 104.14,35.56 104.9,36.07 104.9,39.37 105.22,40.07 Q2.2 | D18.A 106.05,15.62 100.58,10.16 100.58,8.51 M-9BAT.1
  Bottom 0.406: v93.47,33.78 93.47,18.29 95.25,16.51 100.58,16.51 104.14,14.99 | 104.14,14.99 104.14,11.05 M-9BAT.1 | 104.14,14.99 102.62,16 103.63,17.27 103.63,17.78 104.14,18.03 104.14,22.61 102.62,24.13 102.11,25.91 100.33,25.91 v100.33,27.94 | K2.O 95.12,60.33 91.95,60.2 91.19,59.69
  pour Bottom (isolate 0.305): 97.03,9.14 98.04,7.37 102.11,7.37 104.9,10.41 104.9,15.75 100.58,17.78 97.28,18.03 95.5,18.54 95.5,43.94 92.71,45.72 92.71,48.51 93.73,49.53 97.79,49.53 97.79,50.29 98.81,52.32 98.81,59.69 96.27,62.74 91.44,62.74 89.92,61.21 89.92,56.13 90.68,55.37 95.25,55.37 96.52,54.1 96.52,52.58 95.5,51.56 91.44,51.56 91.19,51.31 91.19,13.97 95.76,9.4
N$57
  Top 0.406: VR56.1 142.44,24.02 D33.C
  Top 0.813: TRIM7X.E 141.92,21.27 VR56.1
N$58
  Top 1.27: B4.~1 234.34,70.45 235.27,71.37 B2.AC1
  Bottom 1.27: JP3.1 236.16,76.83 235.2,75.88 235.2,73.72 B2.AC1
N$59
  Top 1.27: B4.~2 231.75,71.53 231.46,71.82 B2.AC2
  Bottom 1.27: JP4.1 231.14,76.52 231.46,76.2 B2.AC2
N$60
  Top 1.27: B6.~1 215.29,70.52 215.9,71.12 215.9,71.18 216.22,71.5 B5.AC1
  Bottom 1.27: JP5.1 217.17,76.71 216.22,75.75 B5.AC1
N$61
  Top 1.27: B6.~2 212.69,71.72 212.41,72.01 B5.AC2
  Bottom 1.27: JP6.1 212.09,76.45 212.41,76.14 B5.AC2
N$62
  Top 0.406: 190.82,22.67 VR66.1 190.29,24.02 D27.A
  Top 0.813: TRIM3-9.A 190.82,21.02 190.82,22.67
N$63
  Top 0.406: VR65.1 199.59,24.02 D22.C
  Top 0.813: TRIM3-9.E 199.07,21.27 VR65.1
N$64
  Top 0.406: Q34.B 188.59,33.47 188.59,33.02 188.59,27.56 191.26,27.56 191.77,27.05 191.77,25.4 192.41,24.77 192.41,24.01 VR66.2 | VR65.2 VR67.1
  Top 0.813: TRIM3-9.S 194.94,22.86 | 194.94,22.86 194.31,23.5 VR66.2 | VR65.2 195.58,23.5 194.94,22.86
N$65
  Top 0.406: 135.89,23.5 VR57.2 135.25,23.82 135.25,24.83 134.62,25.46 134.62,27.05 134.11,27.56 131.44,27.56 131.44,33.8 Q31.B | VR56.2 140.34,23.81 140.34,24.77 140.01,25.08 VR58.1
  Top 0.813: 137.03,23.5 137.79,22.86 TRIM7X.S | 137.03,23.5 135.89,23.5 | VR56.2 138.43,23.5 137.86,22.92 137.03,23.5
N$66
  Top 0.406: VR60.1 152.19,24.02 D25.A
  Top 0.813: TRIM5X.A 152.72,21.27 VR60.1
N$67
  Top 0.406: Q31.C 130.18,30.63 VR20.1
N$68
  Top 0.813: D19.C 164.9,21.82 D20.A
N$69
  Top 0.406: 146.25,87 DDZ2.A 146.08,87.22
  Top 0.813: 146.08,87.22 DTRIM.E
N$70
  Top 0.813: D21.C 203,22.45 D22.A
N$71
  Top 0.813: D26.A 148.79,23.09 D25.C
N$72
  Top 0.406: VR59.1 161.5,24.02 D20.C
  Top 0.813: TRIM5X.E 160.97,21.27 VR59.1
N$73
  Top 0.813: D28.A 186.9,23.5 D27.C
N$74
  Top 0.813: D29.C 225.25,24.31 225.43,23.5 D30.A
N$75
  Top 0.406: U$2.6 157.86,97.41 158.12,97.16 IC1.3 | 163.47,91.23 DRTRM.2
  Top 0.813: DDMEAS.A 163.47,91.23 | DRTRM.2 161.31,91.59 DCMEAS.1 IC1.3
N$76
  Top 0.406: CHARGE.1 92.2,86.87 90.68,85.85 90.68,84.05 VR21.1
N$77
  Top 0.406: OK6X.2 164.47,29.21 163.35,30.33 VR30.1 159.06,33.81 LED4.C
N$78
  Top 0.406: OK4X.2 202.56,29.84 202.08,30.33 VR31.1 197.16,33.81 LED5.C
N$79
  Top 0.406: LED6.C 235.59,33.81 VR32.1 236.22,34.14 236.22,33.02 238.12,31.11 240.03,31.11 240.66,30.48 OK2X.2
N$80
  Top 0.406: OK6X.1 161.93,27.94 163.19,26.67 163.19,23.5 162.56,22.86 162.56,17.14 161.29,15.88 VR35.2
N$81
  Top 0.406: VR33.2 199.39,15.88 200.66,17.14 200.66,22.86 201.29,23.5 201.29,26.67 200.03,27.94 OK4X.1
N$82
  Top 0.406: VR34.2 237.49,15.88 238.76,17.14 238.76,22.86 239.4,23.5 239.4,26.67 238.12,27.94 OK2X.1
N$83
  Top 0.813: DDZ3.A 144.24,90.82 DDZ2.C
N$84
  Top 0.813: CQHV.B CRHV.1 37.67,52.55 CDZHV.C
N$85
  Top 1.27: B8.~1 196.25,70.39 197.17,71.31 B7.AC1
  Bottom 1.27: JP7.1 197.93,76.83 197.17,76.07 B7.AC1
N$86
  Top 0.406: TRIM9X.S 99.69,20.95 100.84,22.1 100.84,23.05 VR50.2 99.83,23.88 99.57,23.88 98.05,25.4 VR51.2 97.66,25.4 97.03,25.4 96.52,24.89 93.98,24.89 93.03,25.47 Q19.B
N$87  (via drill 0.6)
  Top 0.406: Q2S.1 99.95,60.33 v99.06,61.98
  Top 1.27: 94.49,46.99 Q2T.B 96.46,46.16 VR15.2
  Bottom 0.406: v99.06,61.98 99.31,60.71 99.31,51.82 96.77,49.02 96.77,47.24 Q2T.B
  Bottom 1.27: Q2T.B Q29.B
N$88
  Top 0.406: D36.A 133.15,24.02 VR57.1
  Top 0.813: VR57.1 133.67,21.27 TRIM7X.A
N$89
  Top 0.813: D37.C 183.94,22.45 D38.A
N$90
  Top 1.27: B8.~2 193.65,71.09 193.36,71.37 B7.AC2
  Bottom 1.27: JP8.1 193.04,75.69 193.36,75.37 B7.AC2
N$91
  Top 0.406: 129.54,25.83 D36.C
  Top 0.813: D35.A 130.81,22.23 129.54,23.5 129.54,25.83
N$92
  Top 0.406: Q34.C 187.17,31.44 VR26.1
N$93
  Top 0.406: Q22.B 133.35,41.91 132.72,41.27 132.72,29.69 VR20.2 133.35,29.84 137.48,25.72 VR58.2
  Top 0.61: Q20.1 134.88,45.34 134.62,45.09 Q22.B
  Top 1.27: Q22.B 131.44,41.91
  Bottom 1.27: Q22.B Q38.B
N$94
  Top 0.406: LED9X.C 100.56,39.97 VR24.1
N$95
  Top 0.406: OK9X.1 93.98,42.93 91.19,45.47 91.19,77.47 VR21.2
N$96
  Bottom 0.406: SP1.+ 167.64,95.25 165.74,97.16 156.21,97.16 155.57,96.52 IC1.2
N$97
  Top 1.27: B10.~1 177.19,70.52 178.12,71.44 B9.AC1
  Bottom 1.27: JP9.1 178.12,75.88 B9.AC1
N$98
  Top 1.27: B10.~2 174.59,71.02 174.31,71.31 B9.AC2
  Bottom 1.27: JP10.1 173.99,76.58 174.31,76.26 B9.AC2
N$99
  Top 0.406: OK7.1 142.88,27.94 144.15,26.67 144.15,23.5 143.51,22.86 143.51,17.14 142.24,15.88 VR36.2
N$100
  Top 0.406: OK7.2 145.41,29.21 144.3,30.33 VR37.1 138.28,34.14 137.79,33.66 137.31,33.66 LED7.C
N$102
  Top 0.406: Q26.B 171.45,41.91 170.81,41.27 170.81,30.96 VR38.2 171.6,29.21 172.09,29.21 175.58,25.72 VR64.2
  Top 0.61: Q25.1 172.98,44.71 172.72,44.45 Q26.B
  Top 1.27: Q26.B 169.54,41.91
  Bottom 1.27: Q26.B Q40.B
N$103
  Top 0.406: 208.98,41.91 208.91,37.47 208.91,30.07 VR39.2 209.7,29.21 210.19,29.21 213.68,25.72 VR70.2
  Top 0.61: Q24.1 211.08,44.71 210.82,44.45 Q27.B
  Top 1.27: Q27.B 208.98,41.91 207.65,41.91
  Bottom 1.27: Q27.B Q42.B
N$104
  Top 0.406: 247.01,41.91 247.01,31.75 SRC.2 247.8,29.21 248.28,29.21 251.78,25.72 SRB.2
  Top 0.61: Q23.1 249.18,44.71 248.92,44.45 Q28.B
  Top 1.27: Q28.B 247.01,41.91 245.75,41.91
  Bottom 1.27: Q28.B Q44.B
N$105
  Top 0.406: Q32.B 150.49,33.66 150.5,33.02 150.5,27.56 153.16,27.56 153.67,27.05 153.67,25.4 154.31,24.77 154.31,23.81 VR60.2 155.26,23.5 | VR59.2 VR61.1
  Top 0.813: VR59.2 157.48,23.5 156.84,22.86 | TRIM5X.S 156.84,22.86 | 155.26,23.5 156.21,23.5 156.84,22.86
N$106
  Top 0.406: VR63.1 171.25,24.02 D43.A
  Top 0.813: TRIM2-7.A 171.77,21.27 VR63.1
N$107
  Top 0.406: Q33.C 168.12,31.77 VR38.1
N$108
  Top 0.406: VR72.1 228.65,24.4 D29.A
  Top 0.813: TRIM1-9.A 228.92,21.4 228.92,22.04 228.92,22.55 VR72.1
N$109
  Top 0.406: VR68.1 218.65,24.02 D40.C
  Top 0.813: TRIM2-9.E 218.12,21.27 VR68.1
N$110
  Top 0.406: VR62.1 180.54,24.02 D38.C
  Top 0.813: TRIM2-7.E 180.02,21.46 180.02,22.1 180.02,22.55 VR62.1
N$111
  Top 0.406: Q33.B 169.54,33.4 169.54,32.38 169.54,27.56 172.21,27.56 172.72,27.05 172.72,25.4 173.35,24.77 173.35,23.82 | 173.35,23.82 VR63.2 | 174.31,23.5 173.35,23.82 | VR64.1 VR62.2
  Top 0.813: VR62.2 176.53,23.5 175.9,22.86 | TRIM2-7.S 175.9,22.86 | 174.31,23.5 175.26,23.5 175.9,22.86
N$112
  Top 0.406: VR25.1 149.07,31.13 Q32.C
N$113
  Top 0.406: VR69.2 211.46,23.94 211.46,24.77 210.82,25.4 210.82,27.05 210.31,27.56 207.65,27.56 207.65,33.02 207.32,33.98 Q35.B | VR68.2 VR70.1
  Top 0.813: TRIM2-9.S 214,22.86 | 214,22.86 213.36,23.5 VR69.2 | VR68.2 214.63,23.5 214,22.86
N$114
  Top 1.27: B12.~1 158.15,71.09 158.12,71.12 158.12,71.25 159.07,72.2 B11.AC1
  Bottom 1.27: JP11.1 159.77,76.83 159.07,76.14 B11.AC1
N$115
  Top 0.406: VR69.1 209.54,24.46 D45.A
  Top 0.813: TRIM2-9.A 209.87,21.27 VR69.1
N$116
  Top 0.406: VR71.1 237.69,24.02 D24.C
  Top 0.813: TRIM1-9.E 237.17,21.27 VR71.1
N$117
  Top 1.27: B12.~2 155.54,71.09 155.57,71.12 155.57,71.37 155.26,71.69 B11.AC2
  Bottom 1.27: JP12.1 154.94,76.77 155.26,76.45 B11.AC2
N$118
  Top 0.813: D44.A 167.84,23.72 D43.C
N$119
  Top 0.406: 205.74,25.8 D45.C
  Top 0.813: 205.74,25.8 205.74,22.86 206.58,22.02 D46.A
N$120
  Top 0.813: SDZH1.A 244.04,21.82 SDZH2.C
N$121
  Top 0.406: OK5X.2 183.51,29.21 182.4,30.33 VR41.1 178.11,33.81 LED9.C
N$122
  Top 0.406: OK3.2 221.62,29.84 221.13,30.33 VR42.1 216.21,33.81 LED10.C
N$123
  Top 0.406: SOK1.2 259.71,29.84 259.23,30.33 SRLOKD.1 251.46,34.14 SLED1.C
N$124
  Top 0.406: OK5X.1 180.97,27.94 182.25,26.67 182.25,23.5 181.61,22.86 181.61,17.14 180.34,15.88 VR46.2
N$125
  Top 0.406: OK3.1 220.34,26.98 220.34,23.5 219.71,22.86 219.71,17.14 218.44,15.88 VR44.2
N$126
  Top 0.406: SRHOKD.2 256.54,15.88 257.81,17.14 257.81,22.86 258.44,23.5 258.44,26.67 257.18,27.94 SOK1.1
N$127  (via drill 0.6)
  Top 0.406: U$7.1 98.36,28.83 v97.79,27.94 100.2,25.53 VR50.1 102.55,23.83 D17.C 102.82,21.54 102.11,20.83 102.11,19.81 TRIM9X.E
N$128
  Top 0.406: TRIM10X.E 86.89,22.35 VR47.1 87.25,23.77 VR18.1
N$129
  Top 0.406: D18.C 106.05,23.38 D17.A 106.22,25.86 VR4.1
N$130
  Top 0.406: Q30.C 111.12,30.63 VR12.1
N$131  (1 unrouted)
N$132
  Top 0.406: Q30.B 112.33,33.66 112.39,33.02 112.39,27.56 115.06,27.56 115.57,27.05 115.57,25.4 116.2,24.77 116.2,24.13 116.59,23.37 VR54.2 | 118.75,23.5 118.42,23.37 | VR55.1 VR53.2
  Top 0.813: 118.42,23.37 116.59,23.37 | TRIM8X.S 118.75,23.5 VR53.2
N$133
  Top 0.406: 222.25,25.51 D40.A
  Top 0.813: 222.25,25.51 222.25,22.23 222.04,22.02 D39.C
N$134
  Top 0.406: Q36.B 226.38,34.61 226.69,33.02 226.69,27.56 229.36,27.56 229.87,27.05 229.87,25.4 230.5,24.77 230.5,24.19 VR72.2 | VR71.2 | VR71.2 VR73.1 | VR71.2
  Top 0.813: VR71.2 233.68,23.5 233.04,22.86 | 233.04,22.86 TRIM1-9.S | VR72.2 232.41,23.5 233.04,22.86
N$136
  Top 0.406: Q37.2 90,48.68 86.61,50.8 86.61,51.56 JP14.1
N$137
  Top 0.813: D23.C 241.09,21.82 D24.A
N$138  (via drill 0.6)  (2 unrouted)
  Top 0.406: U$1.1 v77.22,40.39 75.95,40.89
N$140
  Top 0.406: Q36.C 225.27,31.77 VR27.2
N$141
  Top 0.406: SROH.1 247.44,24.02 SDZH2.A
  Top 0.813: STRIM01.A 247.97,21.27 SROH.1
N$142
  Top 0.406: SDL2.C 256.54,25.51 256.54,23.5 SROL.1 255.91,23.18
  Top 0.813: 255.91,23.18 255.91,20.32 255.27,19.68 STRIM01.E
N$143
  Top 0.406: SQ1.B 245.43,33.98 245.75,33.02 245.75,27.56 248.41,27.56 248.92,27.05 248.92,25.4 249.56,24.77 249.56,23.5 SROH.2 | SRB.1 SROL.2
  Top 0.813: STRIM01.S 252.09,22.86 | 252.09,22.86 251.46,23.5 SROH.2 | SROL.2 252.73,23.5 252.09,22.86
N$144
  Top 0.406: SDL2.A 260.35,25.51 260.35,21.59 260.14,21.39 SDL1.C
N$145
  Top 0.406: SQ1.C 244.47,30.48 SRC.1
N$146
  Top 0.406: VR1.2 VR45.1 72.08,41.15 Q6.1
N$147
  Top 0.406: VR52.2 103.48,40.65 Q2.1
N$148
  Top 0.406: 105.03,76.83 107.44,75.18 107.44,43.94 106.51,43.01 Q2.3 | 105.03,76.83 104.9,76.96 103,76.96 K2.2 | D9A.A 105.78,77.58 105.03,76.83
N$149  (2 unrouted)
N$150  (1 unrouted)
N$151  (via drill 0.6)
  Top 0.406: U$7.4 102.11,31.3 102.49,30.92 v102.87,30.48 103.06,30.29 105.22,30.29 106.32,31.39 VR52.1
N$152  (3 unrouted)
N$153  (via drill 0.6)
  Top 0.406: U$7.6 98.04,32.26 v97.79,33.02 96.77,33.02 96.01,33.78 96.01,35.62 VR6.1 94.16,35.69 OK9X.4
N$154  (via drill 0.6)
  Top 0.406: U$7.3 102.42,28.32 v102.87,27.94 103.06,28.13 VR4.2
N$155  (1 unrouted)
N$156  (via drill 0.6)
  Top 0.406: 100.33,33.02 U$7.5 | v102.87,33.02 100.33,33.02 | VR5.2 95,26.5 D9A1.C 95.45,28.65 v97.03,30.23 | VR6.2 C1.1 100.52,33.59 100.33,33.02
  Bottom 0.406: v97.03,30.23 99.06,30.23 U$7.5 100.33,32.82 100.58,33.08 102.81,33.08 v102.87,33.02
N$157  (1 unrouted)
N$158  (1 unrouted)
N$159  (via drill 0.5)
  Top 0.406: VR22.1 88.9,38.86 v88.14,39.62 | v79.5,56.64 79.5,56.56 Q13.C
  Bottom 0.406: v88.14,39.62 88.14,49.02 87.63,49.53 84.33,49.53 84.33,55.12 83.82,55.12 v79.5,56.64
N$160  (2 unrouted)
N$161  (2 unrouted)
N$162  (1 unrouted)
N$163
  Top 0.406: VR40.2 VR43.2
N$164
  Top 0.406: VR43.1 73.51,37.24 73.66,37.08 73.66,32.51 74.68,31.5 83.82,31.5 85.34,33.02 85.34,34.29 86.36,35.31 86.36,40.39 86.78,40.81 Q37.3
N$165  (via drill 0.6)
  Top 0.406: U$1.3 80.77,41.66 v82.04,40.39 82.3,40.13 82.3,38.1 81.47,37.27 VR79.1
  Bottom 0.406: v82.04,40.39 82.04,39.88 82.3,39.62
N$166  (6 unrouted)
N$168  (1 unrouted)
  Top 0.406: VR77.1 83.31,35.56 82.3,34.54 80.52,35.05 80.01,34.54 75.95,34.54 75.44,35.05 75.44,36.26 VR78.1
N$169  (via drill 0.6)  (2 unrouted)
  Top 0.406: K1.2 80.69,90.68 D10A2.A | Q5.3 87.17,57.11 v87.12,57.15
  Top 0.813: K1.2 86.87,90.68 89.15,88.39 89.15,58 Q5.3
  Bottom 0.406: v87.12,57.15 80.52,57.15 80.01,57.66 78.99,57.66 77.72,57.15 78.74,55.88 81.03,53.59 81.03,52.83 | 80.01,51.82 79.5,51.82 78.99,51.31 75.69,51.31 75.44,51.05 75.44,50.8 74.93,50.29 74.93,45.65
N$170  (via drill 0.6)  (1 unrouted)
  Top 0.406: v77.22,45.47 U$1.6
OUT1  (via drill 0.6)
  Top 0.406: 34.29,31.06 V-TO1.3 | C-1083.2 37.1,33.66 V-TO1.3 | C-TO92.2 32.38,41.91 33.02,41.27 C-SO8.7 33.02,38.73 32.7,38.42 | 28.26,40.32 CRLM3.2 | 32.7,38.42 32.38,38.1 V-TO1.3 | 20.32,57.15 CMABDT.4 | CCIO1.2 CDZIO.A | 24.88,42.09 CRLM2.2 | 32.38,38.73 32.7,38.73 32.7,38.42
  Top 0.813: 32.38,38.73 31.75,38.73
  Top 1.27: 20.32,57.15 19.05,57.15 18.22,56.71
  Bottom 0.406: 14.86,49.02 14.61,50.8 | A..C.A 14.86,49.02 | C-TO92.2 32.38,41.85 33.02,40.9 35.5,40.9 | 38.8,45.66 39.43,46.29 | 14.86,49.02 CCIO1.2
  Bottom 1.27: 14.61,50.8 14.92,52.32 | 39.43,46.29 CQREG.C
  other vias: 26.04,58.42 23.5,58.42 23.5,55.88 26.04,55.88
  pour Top (hatched): 27.94,53.98 20.95,53.98 arc-90 19.05,52.07 arc-64 11.62,52.26 10.16,55.24 5.08,55.24 5.08,60.33 27.94,60.33
  pour Bottom (isolate 0.813, hatched): 43.18,34.29 41.91,34.29 39.37,36.83 39.37,37.47 38.73,38.1 34.29,38.1 37.47,40.64 38.1,41.27 38.1,43.81 39.37,45.09 40.64,45.72 40.45,47.18 31.62,47.18 arc74 27.43,43.5 27.43,33.72 arc33 38.1,29.84 38.73,29.84
  pour Top (isolate 0.813, rank 3, hatched): 11.43,52.77 20.32,52.7 20.95,45.09 24.13,42.55 32.38,41.91 39.37,34.92 38.73,30.48 38.73,23.5 30.48,23.5 29.84,26.67 22.86,31.11 14.61,34.29 12.06,36.83 12.13,50.86 12.06,51.63
  pour Bottom (rank 3): 27.94,53.98 20.95,47.62 17.14,43.81 12.7,43.81 12.7,49.53 10.79,53.34 5.08,53.34 5.08,60.33 27.94,60.33
  pour Bottom (rank 3): 38.73,26.04 38.73,23.5 30.48,23.5 30.48,26.67 38.1,26.67
OUT2  (via drill 0.6)  (2 unrouted)
  Top 0.406: 25.4,66.67 25.34,66.67 V-SO8.7 | 24.47,73.53 VRT2.1 | VMABDT.4 v40.64,89.53
  Top 0.813: 25.4,66.67 TO92S.2 25.4,73.03 24.47,73.53 | VRT2.1 23.39,75.67 20.66,75.67 19.24,76.83 15.56,76.83 VRT1.2
  Top 1.27: 15.68,98.3 15.68,100.84
  Bottom 0.406: V-1083.2 41.48,74.03
  Bottom 1.27: V-1083.2 V-TO3.3 37.27,78.17 | 15.75,89.98 15.75,92.52
  other vias: 42.55,89.53 42.55,91.44 40.64,91.44
  pour Bottom (isolate 0.813, rank 6, hatched): 40.01,71.75 38.1,70.48 36.83,70.48 36.83,69.85 32.38,62.87 32.38,61.91 13.97,61.91 12.06,64.77 12.06,81.28 13.97,86.36 11.18,91.5 5.08,91.44 5.08,108.58 15.88,108.58 19.68,100.97 20.95,97.79 20.95,92.08 20.32,92.08 15.88,87 15.88,64.77 26.35,68.58 29.21,70.8 32.38,74.3 34.29,77.47 35.56,81.92 36.2,83.82 36.2,94.3 48.9,94.3 48.9,85.53 40.01,85.41
  pour Top (isolate 0.813, rank 2, hatched): 17.34,89.53 13.08,89.6 11.11,91.57 5.08,91.44 5.08,108.58 12.7,108.58 19.68,100.97 20.7,98.49 20.45,94.04 20.45,93.6 20.32,92.08
OUT+
  Top 0.406: A.C C..C C.C
  pour Bottom (isolate 0.813, rank 2, hatched): 11.43,43.81 5.08,43.81 5.08,53.98 9.53,53.98 11.43,50.16
PLUS11  (via drill 0.5, 0.6, 1.3)  (7 unrouted)
  Top 0.406: FDZHV.C FCB.1 269.11,25.27 270.51,26.67 270.51,29.21 271.14,29.84 271.14,30.33 FQ1.E 270.82,30.8 271.78,31.75 271.78,33.02 272.42,33.66 272.42,36.83 273.05,37.47 273.05,38.58 FRIO.1 273.2,39.52 274.32,40.64 274.32,41.43 FRGS.1 273.84,45.14 FQFET.2 | VRT.1 67.18,96.39 67.31,89.15 67.31,11.18 70.36,8.13 70.61,8.13 70.87,7.87 | VR1.1 74.1,38.8 v75.95,38.1 | VR40.1 74.17,30.07 v74.17,30.23 | v77.98,53.59 78.01,53.57 LED10X.A 80.23,51.79 VR74.2 82.62,51.31 83.06,52.58 84.83,54.35 Q14.E | VR76.1 73.47,52 v72.9,52.07
  Top 0.61: PLUS10+.1 v72.77,15.88 73.41,15.24 74.15,15.24 D10.C
  Top 0.813: PSR22.1 PCB.1 75.06,108.59 73.66,109.98 PSOK2.4
  Top 2.54: 273.84,45.14 280.04,50.86 280.04,81.92 271.14,87.63 v177.8,87.63
  Bottom 0.406: 183.6,104.84 S1.2 | (BATT+).1 PLUS10+.1 | 72.77,30.23 72.77,33.4 v75.95,38.1 73.91,38.35 72.9,39.37 | 72.77,30.23 v74.17,30.23 | v72.77,15.88 72.77,30.23 | 72.14,53.59 v77.98,53.59 | v72.9,52.07 72.39,52.32 72.14,52.07
  Bottom 0.61: R2.2 73.32,10.33 71.37,8.38 71.37,8.64 (BATT+).1
  Bottom 1.676: K1.S 72.52,67.18 72.14,66.8 72.14,53.59 72.14,52.07 72.14,9.91 (BATT+).1
  Bottom 2.54: v177.8,87.63 177.8,100.97 180.91,104.84 183.6,104.84
Q0C  (via drill 1)
  Top 0.406: Q44.C 251.52,39.69 254.57,38.16 SRLOKD.2
  Top 0.61: Q23.4 251.42,53.3 v250.19,52.07
  other vias: 250.19,55.24 252.73,55.24 252.73,52.07
  pour Bottom (isolate 0.813, hatched): 260.35,69.85 260.35,47.62 251.46,43.18 242.57,47.62 242.57,69.85
  pour Top (isolate 0.61, rank 2): 259.08,62.87 259.08,49.53 242.57,49.53 242.57,82.55 252.73,82.55 252.73,78.74 245.11,78.74 245.11,62.87
Q2C  (via drill 1)
  Top 0.406: Q43.C 232.41,39.37 235.59,38.35 VR32.2
  Top 0.61: Q7.4 232.41,52.7 v231.14,51.44
  other vias: 233.68,55.24 231.14,55.24 233.68,51.44
  pour Bottom (isolate 0.813, hatched): 241.3,69.85 241.3,47.62 232.41,43.18 223.52,47.62 223.52,69.85
  pour Top (isolate 0.61, rank 2): 240.03,62.87 240.03,49.53 223.52,49.53 223.52,82.55 233.68,82.55 233.68,78.74 226.06,78.74 226.06,62.87
Q3C  (via drill 1)
  Top 0.406: Q42.C 213.36,39.37 216.53,38.23 VR42.2
  Top 0.61: Q24.4 213.36,53.98 v214.63,55.24
  other vias: 212.09,55.24 212.09,51.44 214.63,51.44
  pour Top (isolate 0.61, rank 2): 220.98,62.87 220.98,49.53 204.47,49.53 204.47,82.55 214.63,82.55 214.63,78.74 207.01,78.74 207.01,62.87
  pour Bottom (isolate 0.813, hatched): 222.25,69.85 222.25,47.62 213.36,43.18 204.47,47.62 204.47,69.85
Q4C  (via drill 1)
  Top 0.406: Q41.C 194.31,40.01 197.49,37.97 VR31.2
  Top 0.61: Q8.4 194.31,52.7 v193.04,51.44
  other vias: 195.58,55.24 193.04,55.24 195.58,51.44
  pour Top (isolate 0.61, rank 2): 201.93,62.87 201.93,49.53 185.42,49.53 185.42,82.55 195.58,82.55 195.58,78.74 187.96,78.74 187.96,62.87
  pour Bottom (isolate 0.813, hatched): 203.2,69.85 203.2,47.62 194.31,43.18 185.42,47.62 185.42,69.85
Q5C  (via drill 1)
  Top 0.406: Q40.C 175.26,40.01 178.44,37.91 VR41.2
  Top 0.61: Q25.4 175.26,52.7 v173.99,51.44
  other vias: 176.53,55.24 173.99,55.24 176.53,51.44
  pour Top (isolate 0.61, rank 2): 182.88,62.87 182.88,49.53 166.37,49.53 166.37,82.55 176.53,82.55 176.53,78.74 168.91,78.74 168.91,62.87
  pour Bottom (isolate 0.813, hatched): 184.15,69.85 184.15,47.62 175.26,43.18 166.37,47.62 166.37,69.85
Q6C  (via drill 1)
  Top 0.406: Q39.C 156.21,40.64 159.38,38.04 VR30.2
  Top 0.61: Q9.4 156.21,52.7 v154.94,51.44
  other vias: 157.48,55.24 154.94,55.24 157.48,51.44
  pour Top (isolate 0.61, rank 2): 163.83,62.87 163.83,49.53 147.32,49.53 147.32,82.55 157.48,82.55 157.48,78.74 149.86,78.74 149.86,62.87
  pour Bottom (isolate 0.813, hatched): 165.1,69.85 165.1,47.62 156.21,43.18 147.32,47.62 147.32,69.85
Q7C  (via drill 1)
  Top 0.406: Q38.C 137.16,40.01 140.34,37.97 VR37.2
  Top 0.61: Q20.4 137.16,52.7 v135.89,51.44
  other vias: 138.43,55.24 135.89,55.24 138.43,51.44
  pour Top (isolate 0.61, rank 2): 144.78,62.87 144.78,49.53 128.27,49.53 128.27,82.55 138.43,82.55 138.43,78.74 130.81,78.74 130.81,62.87
  pour Bottom (isolate 0.813, hatched): 146.05,69.85 146.05,47.62 137.16,43.18 128.27,47.62 128.27,69.85
Q8C  (via drill 1)  (1 unrouted)
  Top 0.406: Q21.C 118.11,40.64 121.28,38.1 VR29.2
  Top 0.61: Q3.4 118.11,52.7 v116.84,51.44
  other vias: 119.38,55.24 116.84,55.24 119.38,51.44
  pour Top (isolate 0.61, rank 2): 125.73,62.87 125.73,49.53 109.22,49.53 109.22,82.55 119.38,82.55 119.38,78.74 111.76,78.74 111.76,62.87
  pour Bottom (isolate 0.813, hatched): 127.64,69.85 127.64,47.62 118.75,43.18 109.86,47.62 109.86,69.85
Q9C  (via drill 1)
  Top 0.406: R3.1 98.83,80.26 93.98,80.26 91.95,77.47 92.2,67.82 92.29,67.91 Q2S.4 v100.97,66.29
  Top 1.27: VR24.2 98.93,43.56 99.82,44.45 Q2T.C
  other vias: 103.38,66.42 100.84,69.34
  pour Top (isolate 0.61, rank 2): 106.68,72.52 106.93,50.55 106.17,50.04 99.82,46.74 91.44,50.8 90.17,82.55 100.33,82.55 100.33,78.49 94.23,78.23 97.28,72.52
  pour Bottom (isolate 0.406, rank 2, hatched): 107.44,81.79 107.95,47.62 98.55,45.21 90.68,61.85 89.66,81.79
Q10C  (via drill 0.5, 1)  (3 unrouted)
  Top 0.406: v74.17,46.23 73.55,45.61 Q6.3 73.03,46.1 72.14,46.99 72.14,47.81 VR81.2 71.76,52.51 VR14.2 71.95,55.69 VR13.2
  Bottom 0.406: v74.17,46.23 74.17,50.8 75.44,52.07 78.99,52.07 80.01,53.09 76.96,55.88 76.96,57.4 78.74,59.44 78.74,58.93 Q1.C
  other vias: 82.55,67.31 80.01,67.31
  pour Top (isolate 0.61, rank 2): 87.63,62.87 86.87,62.48 70.36,62.48 71.12,78.49 81.28,78.49 81.28,78.74 83.31,73.91 83.82,67.94
V3  (via drill 0.6)  (4 unrouted)
  Top 0.406: U$1.5 79.76,45.47 v82.3,45.47
V+OUT
  Top 0.406: FRBOUT.1 268.61,38.73 269.56,38.99 269.88,39.22 FRIO.2
  Top 0.813: FRFS.1 265.43,68.58 265.43,43.97 FRBOUT.1
  Bottom 0.406: VOUT(+)1.1 238.76,116.2 239.4,115.57
  Bottom 0.61: F2.2B 272.16,75.18 FRFS.1 269.62,75.56 F2.2A
  Bottom 2.54: PLUS120.1 238.89,115.06 239.4,115.57 241.3,117.47 271.14,117.47 276.86,111.76 276.86,89.53 271.78,84.45 FRFS.1
V-
  Top 0.813: VR-B.1 41.89,95.02 VCQ.B
  Top 1.778: VR-B.1 46.27,95.34 47.62,94.61 VRSHNT.1 47.62,66.67 45.72,64.77 VOUT-.1
  Bottom 2.54: S1.4 194.79,116.99 193.04,118.75 54.61,118.75 52.7,116.84 52.7,71.75 45.72,64.77 VOUT-.1 38.73,64.77 38.35,65.15 VCOUT.-
V_TOT
  Top 0.406: DRTRM.1 162.56,87.63 161.93,87 154.31,87 153.92,87.38 DTRIM.S
V_VENT
  Top 0.61: DQ1.2 123.19,108.08 123.04,107.92 DRTOP.1
  Top 0.813: P_L1.2 98.42,114.43 99.06,115.06 116.2,115.06 | 116.2,115.06 120.02,115.06 123.19,108.08 | 116.2,115.06 VENTILATOR.1
  Bottom 0.406: VENTILATOR.1 PCOUT.+
VENTB  (1 unrouted)
  Top 0.305: SOK1.3 259.71,35.12 | 260.99,83.19 260.99,37.53
  Top 0.406: 127.64,84.45 111.12,84.45 111.44,84.78 | 260.99,83.19 259.08,84.45 241.94,84.45 | 203.84,84.45 184.78,84.45 | 222.88,84.45 203.84,84.45 | 222.88,84.45 241.94,84.45 | 184.78,84.45 166.37,84.45 | 166.37,84.45 146.75,84.45 | 146.75,84.45 127.64,84.45 | 146.75,84.45 146.75,37.53 145.41,36.2 OK7.3 | OK6X.3 164.47,36.2 165.74,37.47 165.74,83.82 166.37,84.45 | 183.51,35.56 OK5X.3 183.51,36.2 184.78,37.47 184.78,84.45 | 202.56,35.56 OK4X.3 202.56,36.2 203.84,37.47 203.84,84.45 | 221.62,35.56 OK3.3 221.62,36.2 222.88,37.47 222.88,84.45 | 240.66,35.56 OK2X.3 240.66,36.2 241.94,37.47 241.94,84.45 | 260.99,37.53 260.99,37.47 259.71,36.2 SOK1.3 | 127.64,84.45 127.64,37.47 126.36,36.2 OK8X.3 | D10A1.C 87.2,29.89 85.85,31.24 85.85,33.53 86.87,34.54 88.58,34.54 VR23.1 88.65,36.13 VR22.2 88.83,36.32 88.14,36.32 87.12,37.34 87.12,40.13 88.46,41.47 Q37.1
  Top 0.813: 111.44,84.78 VQ1.1 110.95,90.97 109.86,92.08 109.86,98.4 | 109.86,98.4 P_Q2.1 | 109.86,98.4 107.62,98.4 VRB.1
VENTMID  (via drill 0.6)  (3 unrouted)
  Top 0.406: v106.93,83.19 107,83.5 107.63,82.55 | v125.73,83.19 126.68,82.55 126.68,37.97 126.17,37.47 125.09,37.47 123.83,36.2 OK8X.4 | v257.81,83.19 260.03,82.42 260.03,37.97 259.52,37.47 258.51,37.47 258.44,37.4 258.38,37.4 257.18,36.2 SOK1.4 | OK7.4 142.88,36.2 144.15,37.47 145.29,37.47 145.73,37.91 145.73,81.22 v144.65,82.55 | 161.93,35.56 OK6X.4 161.93,36.2 163.19,37.47 164.27,37.47 164.78,37.97 164.78,81.92 164.21,82.8 v164.21,82.55 | OK5X.4 180.97,36.2 182.25,37.47 183.32,37.47 183.83,37.97 183.83,81.28 v183.32,83.12 | 200.03,35.56 OK4X.4 200.03,36.2 201.23,37.4 202.31,37.4 202.88,37.97 202.88,81.28 v202.31,83.19 | 219.07,35.56 OK3.4 219.07,36.2 220.34,37.47 221.42,37.47 221.93,37.97 221.93,81.28 v221.36,83.19 | OK2X.4 238.12,36.2 239.4,37.47 240.47,37.47 240.98,37.97 240.98,81.28 v240.35,83.19
  Top 0.813: VRT.2 95,96.37 96.37,96.11 v97.28,94.74 VDZ1.C
  Bottom 0.406: 96.52,83.19 v106.93,83.19 v125.73,83.19 143.51,83.19 144.15,82.55 v144.65,82.55 146.05,83.19 163.19,83.19 163.83,82.55 v164.21,82.55 164.47,83.19 183.51,83.19 | 183.51,83.19 v202.31,83.19 v221.36,83.19 v240.35,83.19 v257.81,83.19 | 183.51,83.19 v183.32,83.12
VIN+  (via drill 1.3)
  Top 0.406: VIN(+).1 23.01,101.75
  Top 1.27: 23.01,101.75 VRHV.2
  Top 1.778: 22.86,109.22 VQHV.C
  Top 2.54: v193.68,91.44 180.97,91.44 177.8,94.61 177.8,111.76 175.26,118.87 27.94,118.87 22.86,109.22
  Bottom 1.27: VQHV.C VIN(+).1
  Bottom 2.54: VIN(+).1 VIN+1.1 | S1.6 194.79,92.56 v193.68,91.44
VIRT-
  Top 0.406: VD2.C 36.94,100.01 VD-S1.A
  Top 0.813: VCAD.- VD2.C 38.1,96.52 VCQ.C
  Bottom 0.813: VCIN.- 27.94,95.25 29.84,97.16 32.38,97.16 33.02,97.79 34.45,97.79 VCAD.-
  pour Top (rank 3): 38.73,103.5 38.73,95.89 36.83,95.89 34.29,97.79 36.2,99.69 37.47,103.5
  pour Bottom (isolate 0.813, rank 5): 33.02,98.42 34.92,99.06 34.92,93.34 26.67,93.34 24.13,95.25
VOUT+REG
  Bottom 2.54: S1.1 183.44,114.31 180.97,114.3 62.23,114.3 57.15,109.22 57.15,69.85 48.26,60.96 VOUT(+)REG.1
  pour Top (isolate 0.813, hatched): 44.45,59.69 40.01,59.69 35.56,60.96 34.29,61.59 32.38,61.91 13.97,61.91 arc-73 5.08,74.3 5.08,88.27 15.24,88.27 12.7,75.56 16.51,73.03 16.51,66.04 20.32,64.77 36.2,64.77 44.45,63.5
VSS  (via drill 0.5, 0.6)  (6 unrouted)
  Top 0.406: v79.76,40.39 U$1.2 | v86.87,20.32 VR19.2 | M-10BAT.1 71.06,19.11 73.15,17.02 74.42,17.02 v76.45,14.99
  Bottom 0.406: 83.31,32.51 81.53,29.46 86.87,21.84 v86.87,20.32 85.6,12.19 77.98,12.19 76.71,13.46 v76.45,14.99 | v79.76,40.39 79.76,38.86

## Text on the board
Top: MICHAEL5.net | 25062012 | MICHAEL5.net | 25062012 | MICHAEL5.net | 25062012 | MICHAEL5.net
Bottom: MICHAEL5.net | MICHAEL5.net | MICHAEL5.net | 22062012
tNames: V_in(+)
tStop: MICHAEL5.net | MICHAEL5.net | MICHAEL5.net | MICHAEL5.net
tTest: V_out(+)