# EAGLE board 22062013crel (EAGLE 5.07), part 1 of 2

Size 285 x 125 mm. Coordinates in mm from the lower left corner, seen from the top.
Outline: 285,0 285,125 0,125 0,0 285,0
Copper layers (1*16): Top 0.035mm / dielectric 1.5mm / Bottom 0.035mm
Design rules "default *": minimum track width 10mil, minimum drill 24mil, track to track 8mil, track to pad 8mil, pad to pad 8mil, via to via 8mil, smd to smd 8mil, copper to edge 40mil, drill to drill 8mil, minimum pad ring 1mil, minimum via ring 8mil, stop-mask expansion 4mil, vias tented up to drill 0mil, thermal gap 10mil
Holes 3.2 mm at 3.17,3.17 46.99,50.8 3.17,50.8 46.99,3.17 3.17,120.65 48.26,109.86 212.72,120.65 279.4,120.65 279.4,3.17 66.04,29.21
Holes 2.5 mm at 137.79,29.84 119.38,29.84 156.84,29.84 176.53,29.84 81.28,29.84 194.94,29.84 214.63,29.84 233.68,29.84 252.73,29.84

## Footprints (pad centres in the part's own frame; a part is rotated, then mirrored left to right if it is on the bottom)
1X4MM5 = drill 4.5 pad 6.35 round: 1 0,0
1X01 = drill 1 pad 1.676 octagon: 1 0,0
TO220ACS = drill 1 pad 1.676 long: A 2.54,-2.54; C -2.54,-2.54
LED3MM = drill 0.8 pad 1.27 octagon: A -1.27,0; K 1.27,0
2KBP = drill 1 pad 1.676 long: + 5.715,0; - -5.715,0; AC1 -1.905,0; AC2 1.905,0
SOIC-4 = smd 1.27 x 2.54: + 1.3,3.685; - -1.3,3.685; ~1 -1.3,-3.685; ~2 1.3,-3.685
SMB = smd 2.4 x 2.4: A 2.2,0; C -2.2,0
C0805 = smd 1.3 x 1.5: 1 -0.95,0; 2 0.95,0
TO247S = drill 1.5 long: 1 -5.588,-2.921; 2 0,-2.921; 3 5.588,-2.921
SO08 = smd 0.6 x 2.2: 1 -1.905,-2.6; 2 -0.635,-2.6; 3 0.635,-2.6; 4 1.905,-2.6; 5 1.905,2.6; 6 0.635,2.6; 7 -0.635,2.6; 8 -1.905,2.6
TO92S = drill 0.6 pad 0.813 long: 1 -1.27,0; 2 0,0; 3 1.27,0
317TS = drill 1 long: 1 -2.54,-2.54; 2 0,-2.54; 3 2.54,-2.54
MINIMELF = smd 1.4 x 1.8: A 1.7,0; C -1.7,0
1X1MM8 = drill 1.6 pad 2.54 octagon: 1 0,0
C1206 = smd 1.6 x 1.8: 1 -1.4,0; 2 1.4,0
C050-025X075 = drill 0.8 pad 1.27 octagon: 1 -2.54,0; 2 2.54,0
E5-6 = drill 0.8 pad 1.905 round: + -2.54,0 | drill 0.8 pad 1.905 octagon: - 2.54,0
SOT23 = smd 1 x 1.4: 1 -0.95,-1.1; 2 0.95,-1.1; 3 0,1.1
DPACK = smd 1.6 x 3: 1 -2.28,-4.8; 3 2.28,-4.8 | smd 5.8 x 6.2: 4 0,2.38
R0805 = smd 1.3 x 1.5: 1 -0.95,0; 2 0.95,0
TO126AV = drill 1 pad 1.27 long: B 2.286,-1.27; C 0,-1.27; E -2.286,-1.27
R1206 = smd 1.6 x 1.803: 1 -1.422,0; 2 1.422,0
R5025 = smd 1.8 x 2.7: 1 -2.2,0; 2 2.2,0
R1210 = smd 1.6 x 2.7: 1 -1.4,0; 2 1.4,0
EVND8AA = drill 1 pad 1.778 long: A -2.5,-2.5; E 2.5,-2.5; S 0.04,2.54
SMC = smd 2.8 x 3.8: A 3.7,0; C -3.7,0
P-LCC-4-3 = smd 3.3 x 4.8: 1 -2,-3.15; 2 -2,3.15; 3 2,3.15; 4 2,-3.15
SOT223 = smd 1.219 x 2.235: 1 -2.311,-3.099; 2 0,-3.099; 3 2.311,-3.099 | smd 3.6 x 2.2: 4 0,3.099
SHK20Q = drill 1.3 pad 3.81 octagon: 1A -7.874,2.75; 1B -7.874,-2.75; 2A 7.874,2.75; 2B 7.874,-2.75
SOD80C = smd 1.4 x 1.8: A 1.7,0; C -1.7,0
SOT23-BEC = smd 1 x 1.4: B -0.95,-1.1; C 0,1.1; E 0.95,-1.1
TO252 = smd 1 x 1.6: 1 -2.28,-4.8; 2 2.28,-4.8 | smd 5.4 x 6.2: 3 0,2.5
0207/15 = drill 0.8 pad 1.27 octagon: 1 -7.62,0; 2 7.62,0
DIL8 = drill 0.8 long: 1 -3.81,-3.81; 2 -1.27,-3.81; 3 1.27,-3.81; 4 3.81,-3.81; 5 3.81,3.81; 6 1.27,3.81; 7 -1.27,3.81; 8 -3.81,3.81
SOT23-5 = smd 0.6 x 1.2: 1 -0.95,-1.306; 2 0,-1.306; 3 0.95,-1.306; 4 0.95,1.306; 5 -0.95,1.306
1X02 = drill 1.016 pad 1.676 long: 1 -1.27,0; 2 1.27,0
G2R = drill 1.2 pad 1.778 long: 1 -2.54,-3.683; 2 -2.54,3.81; O 13.97,-3.683; P 17.45,3.81; S 20.955,-3.683
L5650M = smd 1.8 x 4: 1 -2.5,0; 2 2.5,0
CHIPLED_1206 = smd 1.5 x 1.5: A 0,-1.75; C 0,1.75
SMD4 = smd 1.78 x 1.55: 1 -1.27,-3.5; 2 1.27,-3.5; 3 1.27,3.5; 4 -1.27,3.5
1X01' = drill 1 pad 1.27 square: 1 0,0
E2,5-6 = drill 0.8 pad 1.6 round: + -1.27,0 | drill 0.8 pad 1.6 octagon: - 1.27,0
SOT93V = drill 1.3 pad 1.676 long: B -5.461,-2.54; C 0,-2.54; E 5.461,-2.54
TO220AV = drill 1 pad 1.27 long: B -2.54,-2.54; C 0,-2.54; E 2.54,-2.54
D-PAK_TO252AA = smd 1 x 1.6: 1 -2.28,-4.8; 3 2.28,-4.8 | smd 5.4 x 6.2: 4 0,2.5
SOT93 = drill 1.397 long: B -5.461,-10.16; C 0,-10.16; E 5.461,-10.16 | hole 4.115: 0,10.16
CERAM85 = drill 1 pad 2.54 octagon: 1 -42.5,0; 2 42.5,0
CERAM67 = drill 1 pad 2.54 octagon: 1 -33.5,0; 2 33.5,0
320NEW = drill 1.8 pad 3.81 octagon: 1 -4.928,7.823; 2 -4.928,0; 3 -4.928,-7.823; 4 4.928,7.823; 5 4.928,0; 6 4.928,-7.823
KSS1201 = drill 1 pad 2.159 octagon: + 3.251,0; - -3.251,0
S64W = drill 0.7 long: A 2.54,1.27; E -2.54,1.27; S 0,1.27
RANDL = drill 1 long: A -4,5; E 4,5; S 0,5 | drill 1 square: P$1 -5,-5; P$2 5,-5
SOT23-6 = smd 0.635 x 1.27: 1 -1.016,-1.016; 2 0,-1.016; 3 1.016,-1.016; 4 1.016,1.016; 5 0,1.016; 6 -1.016,1.016
TO3-K02 = drill 1.2 pad 3.81 octagon: 1 -1.778,-5.461; 2 -1.778,5.461 | drill 4.5 pad 6.477 round: 3 15.113,0; 3@ -15.113,0
E5-8,5 = drill 1 pad 2.54 round: + -2.54,0 | drill 1 pad 2.54 octagon: - 2.54,0
1X02' = drill 1 pad 1.27 square: 1 -1.27,0 | drill 1 pad 1.27 octagon: 2 1.27,0
0204V = drill 0.8 pad 1.27 octagon: 1 -1.27,0; 2 1.27,0
R0603 = smd 1 x 1.1: 1 -0.85,0; 2 0.85,0
0204/5 = drill 0.8 pad 1.27 octagon: 1 -2.54,0; 2 2.54,0
R2010 = smd 1.8 x 2.7: 1 -2.2,0; 2 2.2,0
0617/17 = drill 1 pad 1.676 octagon: 1 -8.89,0; 2 8.89,0

## Placement (x,y rotation side)
(BATT+)  [1X4MM5]  71.12,8.89 0 top
(BATT-)  [1X01]  261.62,15.88 0 top
A  [TO220ACS]  11.11,41.59 270 top
A..C  [LED3MM]  12.06,48.9 180 top
B1  [2KBP]  252.41,73.66 180 top
B2  [2KBP]  233.36,73.66 180 top
B3  MB1S  [SOIC-4]  252.09,66.04 180 top
B4  MB1S  [SOIC-4]  233.04,66.04 180 top
B5  [2KBP]  214.31,73.66 180 top
B6  MB1S  [SOIC-4]  214,66.04 180 top
B7  [2KBP]  195.26,73.66 180 top
B8  MB1S  [SOIC-4]  194.94,66.04 180 top
B9  [2KBP]  176.21,73.66 180 top
B10  MB1S  [SOIC-4]  175.9,66.04 180 top
B11  [2KBP]  157.16,73.66 180 top
B12  MB1S  [SOIC-4]  156.84,66.04 180 top
C  [SMB]  10.48,41.59 270 top
C1  [C0805]  101.47,35.69 0 top
C2  [C0805]  85.09,42.67 270 top
C-1083  LT1083CP-V  [TO247S]  44.45,33.66 270 top
C-SO8  [SO08]  32.38,43.18 180 top
C-TO92  [TO92S]  32.38,43.18 0 top
C-TS  [317TS]  44.07,33.66 270 top
C.  1N4148MINIMELF  [MINIMELF]  9.84,41.59 270 top
C_VIN+  [1X1MM8]  36.2,55.24 0 top
CCIO  [C1206]  21.59,48.9 180 top
CCIO1  [C050-025X075]  21.59,48.9 180 top
CCOUT  [E5-6]  34.92,22.86 270 top
CD4  BAS40-04  [SOT23]  12.13,31.5 180 top
CDT3L1  [MINIMELF]  7.62,34.29 90 top
CDT3L2  [MINIMELF]  10.16,34.29 90 top
CDZHV  1N4148MINIMELF  [MINIMELF]  36.89,50.86 270 top
CDZIO  [MINIMELF]  22.23,51.44 180 top
CHARGE  [1X01]  93.73,86.87 0 top
CMABDT  LM317MABDT  [DPACK]  26.99,57.15 90 top
CO1  [R0805]  38.99,57.91 270 top
CQHV  BD139  [TO126AV]  43.18,55.24 270 top
CQREG  BD139  [TO126AV]  43.12,46.55 270 top
CRHV  [R1206]  39.12,53.34 90 top
CRLM1  [R5025]  20.32,45.72 180 top
CRLM2  [R1210]  25.65,43.18 270 top
CRLM3  [R1206]  28.57,43.18 270 top
CRT2H  [R1206]  23.81,29.21 90 top
CTRIM2  [EVND8AA]  25.4,22.86 90 top
CTRIM3  [EVND8AA]  15.19,22.86 90 top
D1  [MINIMELF]  not placed on the board
D2  [SMC]  20.57,119.13 0 top
D3  [MINIMELF]  69.34,43.69 270 top
D9  [MINIMELF]  92.9,19.56 90 top
D9A  [MINIMELF]  104.08,80.71 0 top
D9A1  [MINIMELF]  93.98,30.35 90 top
D10  [MINIMELF]  74.23,17.02 90 top
D10A  [MINIMELF]  72.45,22.03 90 top
D10A1  [MINIMELF]  88.65,28.19 270 top
D10A2  [MINIMELF]  75.31,94.36 0 top
D12  [MINIMELF]  125.09,25.72 180 top
D13  [MINIMELF]  126.36,20.32 90 top
D14  [MINIMELF]  111.76,20.32 90 top
D15  [MINIMELF]  112.39,25.72 0 top
D17  [MINIMELF]  104.52,23.56 0 top
D18  [MINIMELF]  106.05,19.43 270 top
D19  [MINIMELF]  164.47,20.32 270 top
D20  [MINIMELF]  163.19,25.72 0 top
D21  [MINIMELF]  202.56,20.32 270 top
D22  [MINIMELF]  201.29,25.72 0 top
D23  [MINIMELF]  240.66,19.68 270 top
D24  [MINIMELF]  239.4,25.72 0 top
D25  [MINIMELF]  150.5,25.72 0 top
D26  [MINIMELF]  149.86,20.32 90 top
D27  [MINIMELF]  188.59,25.72 0 top
D28  [MINIMELF]  187.32,20.32 90 top
D29  [MINIMELF]  226.82,25.72 0 top
D30  [MINIMELF]  225.43,20.32 90 top
D33  [MINIMELF]  144.15,25.72 0 top
D34  [MINIMELF]  145.41,20.32 270 top
D35  [MINIMELF]  130.81,20.32 90 top
D36  [MINIMELF]  131.44,25.72 0 top
D37  [MINIMELF]  183.51,20.32 270 top
D38  [MINIMELF]  182.25,25.72 0 top
D39  [MINIMELF]  221.62,20.32 270 top
D40  [MINIMELF]  220.34,25.72 0 top
D43  [MINIMELF]  169.54,25.72 0 top
D44  [MINIMELF]  168.91,20.32 90 top
D45  [MINIMELF]  207.65,25.72 0 top
D46  [MINIMELF]  207.01,20.32 90 top
DCBLK1  [E5-6]  144.15,99.06 90 top
DCBLK2  [C1206]  148.72,97.41 90 top
DCMEAS  [C1206]  158.75,90.17 270 top
DDMEAS  [MINIMELF]  165.74,89.53 90 top
DDZ1  [MINIMELF]  124.46,101.09 180 top
DDZ2  [MINIMELF]  145.61,89.09 270 top
DDZ3  [MINIMELF]  143,91.76 270 top
DLED  [P-LCC-4-3]  135.89,97.16 0 top
DQ1  BCX56  [SOT223]  125.73,108.08 90 top
DRBLU  [R1206]  139.06,105.41 0 top
DRGRN  [R1206]  139.7,87.63 0 top
DRRED  [R1206]  133.99,87.63 0 top
DRTOP  [R1206]  124.46,103.63 0 top
DRTRM  [R1206]  162.56,89.53 90 top
DTRIM  [EVND8AA]  151.38,89.73 270 top
F2  [SHK20Q]  271.78,67.31 90 top
FCB  10n  [C1206]  268.61,26.67 90 top
FDZHV  [SOD80C]  268.61,20.95 270 top
FQ1  BC807-40SMD  [SOT23-BEC]  269.88,31.75 0 top
FQFET  FDD4141TO252  [TO252]  271.78,50.16 0 top
FQHVU  BC846  [SOT23]  273.05,27.3 0 top
FRBOUT  180k  [R1206]  267.97,37.47 270 top
FRFS  0  [0207/15]  271.78,67.94 270 top
FRGS  33k  [R1206]  272.42,41.91 180 top
FRGTE  120k  [R1206]  272.42,35.56 0 top
FRHVL  0.6/200u  [R1206]  272.42,22.86 0 top
FRHVT  14/3m  [R1206]  272.42,19.68 180 top
FRIO  270k  [R1206]  271.78,38.73 180 top
IC1  PIC12F675P  [DIL8]  156.84,98.42 0 top
IC2  LM321MF  [SOT23-5]  84.84,46.48 90 top
JP1  [1X01]  255.27,76.83 0 top
JP2  [1X01]  250.19,76.83 0 top
JP3  [1X01]  236.22,76.83 0 top
JP4  [1X01]  231.14,76.83 0 top
JP5  [1X01]  217.17,76.83 0 top
JP6  [1X01]  212.09,76.83 0 top
JP7  [1X01]  198.12,76.83 0 top
JP8  [1X01]  193.04,76.83 0 top
JP9  [1X01]  179.07,76.83 0 top
JP10  [1X01]  173.99,76.83 0 top
JP11  [1X01]  160.02,76.83 0 top
JP12  [1X01]  154.94,76.83 0 top
JP13  [1X01]  140.97,76.83 0 top
JP14  [1X02]  87.38,52.07 0 top
JP17  [1X02]  not placed on the board
K1  G2R  [G2R]  80.26,88.14 270 top
K2  G2R  [G2R]  99.06,74.3 270 top
L2  [L5650M]  92.08,109.98 270 top
LED4  [CHIPLED_1206]  156.21,35.56 180 top
LED5  [CHIPLED_1206]  194.31,35.56 180 top
LED6  [CHIPLED_1206]  232.41,35.56 180 top
LED7  [CHIPLED_1206]  137.16,35.56 180 top
LED8X  [CHIPLED_1206]  118.11,35.56 180 top
LED9  [CHIPLED_1206]  175.26,35.56 180 top
LED9X  [CHIPLED_1206]  98.81,39.12 270 top
LED10  [CHIPLED_1206]  213.36,35.56 180 top
LED10X  [CHIPLED_1206]  79.57,50.55 180 top
M-9BAT  [1X01]  100.33,8.26 0 top
M-10BAT  [1X01]  71.06,72.77 0 top
MINUS1-  [1X4MM5]  261.62,8.89 0 top
MINUS2-  [1X4MM5]  242.57,8.89 0 top
MINUS3-  [1X4MM5]  223.52,8.89 0 top
MINUS4-  [1X4MM5]  204.47,8.89 0 top
MINUS5-  [1X4MM5]  185.42,8.89 0 top
MINUS6-  [1X4MM5]  166.37,8.89 0 top
MINUS7-  [1X4MM5]  147.32,8.89 0 top
MINUS8-  [1X4MM5]  128.27,8.89 0 top
MINUS9-  [1X4MM5]  109.22,8.89 0 top
MINUS10  [1X4MM5]  90.17,8.89 0 top
MINUS60  [1X4MM5]  257.89,104.7 0 top
MINUS120  [1X4MM5]  219.89,104.7 0 top
OK2X  SFH6186-2  [SMD4]  239.4,31.75 0 top
OK3  SFH6186-2  [SMD4]  220.34,31.75 0 top
OK4X  SFH6186-2  [SMD4]  201.29,31.75 0 top
OK5X  SFH6186-2  [SMD4]  182.25,31.75 0 top
OK6X  SFH6186-2  [SMD4]  163.19,31.75 0 top
OK7  SFH6186-2  [SMD4]  144.15,31.75 0 top
OK8X  SFH6186-2  [SMD4]  125.09,31.75 0 top
OK9X  SFH6186-2  [SMD4]  92.71,39.05 180 top
OUT+  [1X01']  7.62,52.07 0 top
P_L1  [L5650M]  98.42,109.98 90 top
P_Q2  BCX56  [SOT223]  112.39,101.73 0 top
PCB  [C1206]  73.66,106.81 180 top
PCOUT  [E2,5-6]  106.05,109.98 270 top
PCT1  [C1206]  68.58,106.81 180 top
PDHOT  [SMB]  102.87,102.36 0 top
PLUS1+  [1X01]  242.57,15.88 0 top
PLUS2+  [1X01]  223.52,15.88 0 top
PLUS3+  [1X01]  204.47,15.88 0 top
PLUS4+  [1X01]  185.42,15.88 0 top
PLUS5+  [1X01]  166.37,15.88 0 top
PLUS6+  [1X01]  147.32,15.88 0 top
PLUS7+  [1X01]  128.27,15.88 0 top
PLUS8+  [1X01]  109.22,15.88 0 top
PLUS9+  [1X01]  90.17,15.88 0 top
PLUS10+  [1X01]  71.12,15.88 0 top
PLUS120  [1X4MM5]  238.89,104.7 0 top
PQ1  BC857  [SOT223]  93.98,102.36 270 top
PQ2  BC857  [SOT23-BEC]  86.36,102.36 270 top
PRE  [R1210]  76.83,101.73 0 top
PS16  [R1206]  69.22,111.25 270 top
PSOK2  SFH6186-2  [SMD4]  75.56,111.25 90 top
PSR22  [R1206]  78.74,106.81 0 top
PSR23  [R1206]  81.92,111.25 90 top
PZDFB  [MINIMELF]  85.72,111.25 270 top
Q1  TIP142SOT93V  [SOT93V]  80.01,62.99 0 top
Q1T  TIP120TO220V  [TO220AV]  80.01,62.99 0 top
Q2  BC847CSMD  [SOT23]  104.27,41.91 0 top
Q2S  TIP120  [D-PAK_TO252AA]  102.23,65.41 0 top
Q2T  TIP120TO220V  [TO220AV]  99.82,49.53 0 top
Q3  TIP120  [D-PAK_TO252AA]  118.11,50.8 0 top
Q4  BC857CSMD  [SOT23-BEC]  121.92,69.09 0 top
Q5  BC847CSMD  [SOT23]  88.27,56.01 0 top
Q6  BC847CSMD  [SOT23]  73.03,44.51 0 top
Q7  TIP120  [D-PAK_TO252AA]  232.41,50.8 0 top
Q8  TIP120  [D-PAK_TO252AA]  194.31,50.8 0 top
Q9  TIP120  [D-PAK_TO252AA]  156.21,50.8 0 top
Q10  BC857CSMD  [SOT23-BEC]  122.94,76.96 0 top
Q10S  TIP120  [D-PAK_TO252AA]  82.04,81.66 0 top
Q11  BC857CSMD  [SOT23-BEC]  not placed on the board
Q12  BC847ASMD  [SOT23]  not placed on the board
Q13  BC857CSMD  [SOT23-BEC]  77.47,55.63 270 top
Q14  BC857CSMD  [SOT23-BEC]  83.88,55.94 0 top
Q15  TIP120TO220V  [TO220AV]  118.11,44.45 0 top
Q16  TIP120TO220V  [TO220AV]  156.21,44.45 0 top
Q17  TIP120TO220V  [TO220AV]  194.31,44.45 0 top
Q18  TIP120TO220V  [TO220AV]  232.41,44.45 0 top
Q19  BC857CSMD  [SOT23-BEC]  91.95,24.89 180 top
Q20  TIP120  [D-PAK_TO252AA]  137.16,50.8 0 top
Q21  TIP142SOT93V  [SOT93V]  118.11,44.45 0 top
Q22  TIP120TO220V  [TO220AV]  137.16,44.45 0 top
Q23  TIP120  [D-PAK_TO252AA]  251.46,50.8 0 top
Q24  TIP120  [D-PAK_TO252AA]  213.36,50.8 0 top
Q25  TIP120  [D-PAK_TO252AA]  175.26,50.8 0 top
Q26  TIP120TO220V  [TO220AV]  175.26,44.45 0 top
Q27  TIP120TO220V  [TO220AV]  213.36,44.45 0 top
Q28  TIP120TO220V  [TO220AV]  251.46,44.45 0 top
Q29  TIP142SOT93V  [SOT93V]  99.82,49.53 0 top
Q30  BC857CSMD  [SOT23-BEC]  111.12,33.02 180 top
Q31  BC857CSMD  [SOT23-BEC]  130.18,33.02 180 top
Q32  BC857CSMD  [SOT23-BEC]  149.22,33.02 180 top
Q33  BC857CSMD  [SOT23-BEC]  168.28,33.02 180 top
Q34  BC857CSMD  [SOT23-BEC]  187.32,33.02 180 top
Q35  BC857CSMD  [SOT23-BEC]  206.38,33.02 180 top
Q36  BC857CSMD  [SOT23-BEC]  225.43,33.02 180 top
Q37  BC847CSMD  [SOT23]  87.88,42.42 90 top
Q38  TIP142SOT93V  [SOT93V]  137.16,44.45 0 top
Q39  TIP142SOT93V  [SOT93V]  156.21,44.45 0 top
Q40  TIP142SOT93V  [SOT93V]  175.26,44.45 0 top
Q41  TIP142SOT93V  [SOT93V]  194.31,44.45 0 top
Q42  TIP142SOT93V  [SOT93V]  213.36,44.45 0 top
Q43  TIP142SOT93V  [SOT93V]  232.41,44.45 0 top
Q44  TIP142SOT93V  [SOT93V]  251.46,44.45 0 top
Q45  BD680  [TO126AV]  10.67,113.03 0 top
Q46  TIP147  [SOT93]  not placed on the board
R2  [CERAM85]  80.26,52.83 270 bottom
R3  [CERAM67]  99.06,46.99 270 top
R4  [CERAM67]  118.11,46.99 270 top
R5  [CERAM67]  137.16,46.99 270 top
R13  [CERAM67]  175.26,46.99 270 top
R14  [CERAM67]  156.21,46.99 270 top
R16  [CERAM67]  194.31,46.99 270 top
R18  [CERAM67]  232.41,46.99 270 top
R21  [CERAM67]  213.36,46.99 270 top
R24  [CERAM67]  251.46,46.99 270 top
S1  [320NEW]  189.87,105.41 0 top
SDL1  [MINIMELF]  259.71,19.68 270 top
SDL2  [MINIMELF]  258.44,25.72 0 top
SDZH1  [MINIMELF]  244.47,19.68 90 top
SDZH2  [MINIMELF]  245.75,25.72 0 top
SLED1  [CHIPLED_1206]  251.46,35.56 180 top
SOK1  SFH6186-2  [SMD4]  258.44,31.75 0 top
SP1  KSS1201  [KSS1201]  168.28,98.14 270 top
SP2  KSS1201  [KSS1201]  116.59,-2.54 0 top
SP3  KSS1201  [KSS1201]  80.77,29.46 180 top
SQ1  BC857CSMD  [SOT23-BEC]  244.47,33.02 180 top
SRB  [R0805]  253.37,25.72 180 top
SRC  [R1206]  245.75,29.84 0 top
SRHOKD  [R1206]  247.65,15.88 0 top
SRLOKD  [R1206]  254.63,35.56 90 top
SROH  [R0805]  248.92,23.5 0 top
SROL  [R0805]  255.27,23.5 180 top
STRIM01  [S64W]  252.09,20.95 180 top
TO92S  [TO92S]  25.4,68.58 0 top
TRIM1-9  [S64W]  233.04,20.95 180 top
TRIM2-7  [S64W]  175.9,20.95 180 top
TRIM2-9  [S64W]  214,20.95 180 top
TRIM3-9  [S64W]  194.94,20.95 180 top
TRIM3X  [RANDL]  12.7,22.86 270 top
TRIM5X  [S64W]  156.84,20.95 180 top
TRIM7X  [S64W]  137.79,20.95 180 top
TRIM8X  [S64W]  118.75,20.95 180 top
TRIM9X  [S64W]  99.69,20.95 180 top
TRIM10X  [S64W]  80.64,21.59 180 top
TRIM10X1  [S64W]  80.64,15.75 180 top
U$1  PIC10F204OT  [SOT23-6]  79.76,42.93 0 top
U$2  PIC10F204OT  [SOT23-6]  153.03,98.42 180 top
U$7  PIC10F204OT  [SOT23-6]  100.33,30.48 0 top
V-1083  LT1083CP-V  [TO247S]  44.83,73.98 270 top
V-SO8  [SO08]  25.4,68.58 180 top
V-TO1  [TO3-K02]  26.3,44.45 225 bottom
V-TO3  [TO3-K02]  26.4,84.72 225 bottom
V-TS  [317TS]  44.45,73.98 270 top
VCAD  [E2,5-6]  34.51,96.46 90 top
VCHI  [C050-025X075]  29.27,102.87 0 top
VCIN  [E2,5-6]  24.77,94.61 0 top
VCIO  [C1206]  16.38,87.5 180 top
VCLO  [C050-025X075]  35.56,106.36 0 top
VCOUT  [E5-8,5]  34.29,65.15 0 top
VCQ  BC817-40LT1SMD  [SOT23-BEC]  39.5,96.01 90 top
VD2  [MINIMELF]  38.93,99.06 0 top
VD-S1  [MINIMELF]  36.39,102.81 0 top
VD-S2  [MINIMELF]  32,98.11 90 top
VDIO  [MINIMELF]  20.7,91.25 180 top
VDZ1  [MINIMELF]  100.46,96.9 0 top
VENTILATOR  [1X02']  116.2,109.98 270 top
VFUSE  [SHK20Q]  8.89,94.61 90 top
VIN(+)  [1X1MM8]  22.86,101.22 270 top
VIN(-)  [1X01']  41.91,104.14 270 top
VIN(-)1  [1X01']  31.75,17.78 270 top
VIN+1  [1X01']  22.86,99.06 270 top
VMABDT  LM317MABDT  [DPACK]  38.99,90.49 270 top
VMINUS(-)  [1X1MM8]  47.62,104.14 0 top
VO1  [0204V]  27.69,80.64 270 top
VO2  [0204V]  20.13,64.9 180 top
VOUT(+)  [1X01]  7.62,48.26 270 top
VOUT(+)1  [1X01]  238.76,117.47 0 top
VOUT(+)REG  [1X01]  41.91,60.96 270 top
VOUT-  [1X01]  41.91,64.77 180 top
VPOT1  [RANDL]  12.7,70.8 270 top
VPOT2  [S64W]  16.45,70.8 270 top
VQ1  BC847  [SOT23]  112.39,92.08 0 top
VQHV  TIP41C  [TO220AV]  22.86,109.22 0 top
VR1  [R0805]  73.15,39.18 180 top
VR2  [R0603]  74.55,21.65 270 top
VR3  [0204/5]  29.53,96.58 270 top
VR3X  [R1206]  29.53,96.52 270 top
VR4  [R0805]  105.85,27.18 90 top
VR5  [R1206]  95.31,24.89 90 top
VR6  [R0805]  97.03,35.69 0 top
VR7  [R1206]  not placed on the board
VR8  [R1206]  not placed on the board
VR8X  [0204V]  33.66,86.04 180 top
VR9  [R1206]  not placed on the board
VR10  [R1206]  123.44,64.01 0 top
VR11  [R0805]  83.06,58.42 180 top
VR12  [R1206]  112.39,29.84 0 top
VR13  [R0805]  73.41,56.26 180 top
VR14  [R0805]  73.22,54.1 180 top
VR15  [R0805]  96.46,42.55 90 top
VR16  [R1206]  116.08,64.26 0 top
VR17  [R1206]  117.09,73.15 0 top
VR18  [R1206]  88.9,22.35 270 top
VR19  [R1206]  86.87,17.02 90 top
VR20  [R1206]  131.44,29.84 0 top
VR21  [R1206]  93.22,83.69 0 top
VR22  [R0805]  88.9,37.34 270 top
VR23  [R0805]  88.65,33.53 270 top
VR24  [R0805]  98.93,42.55 90 top
VR25  [R1206]  150.5,29.84 0 top
VR26  [R1206]  188.59,29.84 0 top
VR27  [R1206]  226.69,29.84 180 top
VR28  [R1206]  114.3,15.88 0 top
VR29  [R1206]  121.28,35.56 90 top
VR30  [R1206]  159.38,35.56 90 top
VR31  [R1206]  197.49,35.56 90 top
VR32  [R1206]  235.59,35.56 90 top
VR33  [R1206]  190.5,15.88 0 top
VR34  [R1206]  228.6,15.88 0 top
VR35  [R1206]  152.4,15.88 0 top
VR36  [R1206]  133.35,15.88 0 top
VR37  [R1206]  140.34,35.56 90 top
VR38  [R1206]  169.54,29.84 0 top
VR39  [R1206]  207.65,29.84 0 top
VR40  [R1206]  72.39,31.05 90 top
VR41  [R1206]  178.44,35.56 90 top
VR42  [R1206]  216.53,35.56 90 top
VR43  [R1206]  72.39,35.81 270 top
VR44  [R1206]  209.55,15.88 0 top
VR45  [R0805]  73.15,41.15 0 top
VR46  [R1206]  171.45,15.88 0 top
VR47  [R0603]  86.23,23.94 180 top
VR48  [R0805]  72.39,26.67 270 top
VR49  [R0805]  81.03,56.13 270 top
VR50  [R0805]  100.46,24.45 270 top
VR51  [R0805]  97.73,24.45 90 top
VR52  [R1206]  104.9,38.16 180 top
VR53  [R0805]  121.92,23.5 180 top
VR54  [R0805]  115.57,23.5 0 top
VR55  [R0805]  120.02,25.72 180 top
VR56  [R0805]  140.97,23.5 180 top
VR57  [R0805]  134.62,23.5 0 top
VR58  [R0805]  139.06,25.72 180 top
VR59  [R0805]  160.02,23.5 180 top
VR60  [R0805]  153.67,23.5 0 top
VR61  [R0805]  158.12,25.72 180 top
VR62  [R0805]  179.07,23.5 180 top
VR63  [R0805]  172.72,23.5 0 top
VR64  [R0805]  177.16,25.72 180 top
VR65  [R0805]  198.12,23.5 180 top
VR66  [R0805]  191.77,23.5 0 top
VR67  [R0805]  196.22,25.72 180 top
VR68  [R0805]  217.17,23.5 180 top
VR69  [R0805]  210.82,23.5 0 top
VR70  [R0805]  215.26,25.72 180 top
VR71  [R0805]  236.22,23.5 180 top
VR72  [R0805]  229.87,23.5 0 top
VR73  [R0805]  234.31,25.72 180 top
VR74  [R0805]  81.79,50.29 90 top
VR75  [R0805]  77.22,49.28 270 top
VR76  [R0805]  74.42,50.55 0 top
VR77  [R0805]  84.07,36.83 0 top
VR78  [R0805]  76.45,36.32 0 top
VR79  [R0805]  80.52,36.89 180 top
VR80  [R0805]  76.2,42.93 270 top
VR81  [R0805]  73.34,48.58 180 top
VR-B  [R2010]  43.31,97.54 90 top
VRB  [R1206]  107.31,97.28 270 top
VRB1  [R1206]  34.48,84.01 180 top
VRB2  [R1206]  21.59,69.85 90 top
VRHV  [R1206]  21.59,103.89 0 top
VRSHNT  [0617/17]  47.62,91.44 90 top
VRT  [R1206]  92.08,96.39 0 top
VRT1  390  [0207/15]  22.86,77.15 180 top
VRT2  [R1206]  22.86,73.66 180 top
VRT3  [R1206]  13.34,80.64 0 top
VRT4  390  [0207/15]  -10.41,123.7 0 top
VTRIM1  [EVND8AA]  27.62,81.92 90 top
VZDHV  [MINIMELF]  15.94,106.3 180 top