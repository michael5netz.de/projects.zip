# EAGLE board 01052013a (EAGLE 5.07), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N$95 (continued)
  Top 0.406: OK9X.1 93.98,42.93 91.19,45.47 91.19,77.47 VR21.2
N$96
  Bottom 0.406: SP1.+ 167.64,95.25 165.74,97.16 156.21,97.16 155.57,96.52 IC1.2
N$97
  Top 1.27: B10.~1 177.19,70.52 178.12,71.44 B9.AC1
  Bottom 1.27: JP9.1 178.12,75.88 B9.AC1
N$98
  Top 1.27: B10.~2 174.59,71.02 174.31,71.31 B9.AC2
  Bottom 1.27: JP10.1 173.99,76.58 174.31,76.26 B9.AC2
N$99
  Top 0.406: OK7.1 142.88,27.94 144.15,26.67 144.15,23.5 143.51,22.86 143.51,17.14 142.24,15.88 VR36.2
N$100
  Top 0.406: OK7.2 145.41,29.21 144.3,30.33 VR37.1 138.28,34.14 137.79,33.66 137.31,33.66 LED7.C
N$102
  Top 0.406: Q26.B 171.45,41.91 170.81,41.27 170.81,30.96 VR38.2 171.6,29.21 172.09,29.21 175.58,25.72 VR64.2
  Top 0.61: Q25.1 172.98,44.71 172.72,44.45 Q26.B
  Top 1.27: Q26.B 169.54,41.91
  Bottom 1.27: Q26.B Q40.B
N$103
  Top 0.406: 208.98,41.91 208.91,37.47 208.91,30.07 VR39.2 209.7,29.21 210.19,29.21 213.68,25.72 VR70.2
  Top 0.61: Q24.1 211.08,44.71 210.82,44.45 Q27.B
  Top 1.27: Q27.B 208.98,41.91 207.65,41.91
  Bottom 1.27: Q27.B Q42.B
N$104
  Top 0.406: 247.01,41.91 247.01,31.75 SRC.2 247.8,29.21 248.28,29.21 251.78,25.72 SRB.2
  Top 0.61: Q23.1 249.18,44.71 248.92,44.45 Q28.B
  Top 1.27: Q28.B 247.01,41.91 245.75,41.91
  Bottom 1.27: Q28.B Q44.B
N$105
  Top 0.406: Q32.B 150.49,33.66 150.5,33.02 150.5,27.56 153.16,27.56 153.67,27.05 153.67,25.4 154.31,24.77 154.31,23.81 VR60.2 155.26,23.5 | VR59.2 VR61.1
  Top 0.813: VR59.2 157.48,23.5 156.84,22.86 | TRIM5X.S 156.84,22.86 | 155.26,23.5 156.21,23.5 156.84,22.86
N$106
  Top 0.406: VR63.1 171.25,24.02 D43.A
  Top 0.813: TRIM2-7.A 171.77,21.27 VR63.1
N$107
  Top 0.406: Q33.C 168.12,31.77 VR38.1
N$108
  Top 0.406: VR72.1 228.65,24.4 D29.A
  Top 0.813: TRIM1-9.A 228.92,21.4 228.92,22.04 228.92,22.55 VR72.1
N$109
  Top 0.406: VR68.1 218.65,24.02 D40.C
  Top 0.813: TRIM2-9.E 218.12,21.27 VR68.1
N$110
  Top 0.406: VR62.1 180.54,24.02 D38.C
  Top 0.813: TRIM2-7.E 180.02,21.46 180.02,22.1 180.02,22.55 VR62.1
N$111
  Top 0.406: Q33.B 169.54,33.4 169.54,32.38 169.54,27.56 172.21,27.56 172.72,27.05 172.72,25.4 173.35,24.77 173.35,23.82 | 173.35,23.82 VR63.2 | 174.31,23.5 173.35,23.82 | VR64.1 VR62.2
  Top 0.813: VR62.2 176.53,23.5 175.9,22.86 | TRIM2-7.S 175.9,22.86 | 174.31,23.5 175.26,23.5 175.9,22.86
N$112
  Top 0.406: VR25.1 149.07,31.13 Q32.C
N$113
  Top 0.406: VR69.2 211.46,23.94 211.46,24.77 210.82,25.4 210.82,27.05 210.31,27.56 207.65,27.56 207.65,33.02 207.32,33.98 Q35.B | VR68.2 VR70.1
  Top 0.813: TRIM2-9.S 214,22.86 | 214,22.86 213.36,23.5 VR69.2 | VR68.2 214.63,23.5 214,22.86
N$114
  Top 1.27: B12.~1 158.15,71.09 158.12,71.12 158.12,71.25 159.07,72.2 B11.AC1
  Bottom 1.27: JP11.1 159.77,76.83 159.07,76.14 B11.AC1
N$115
  Top 0.406: VR69.1 209.54,24.46 D45.A
  Top 0.813: TRIM2-9.A 209.87,21.27 VR69.1
N$116
  Top 0.406: VR71.1 237.69,24.02 D24.C
  Top 0.813: TRIM1-9.E 237.17,21.27 VR71.1
N$117
  Top 1.27: B12.~2 155.54,71.09 155.57,71.12 155.57,71.37 155.26,71.69 B11.AC2
  Bottom 1.27: JP12.1 154.94,76.77 155.26,76.45 B11.AC2
N$118
  Top 0.813: D44.A 167.84,23.72 D43.C
N$119
  Top 0.406: 205.74,25.8 D45.C
  Top 0.813: 205.74,25.8 205.74,22.86 206.58,22.02 D46.A
N$120
  Top 0.813: SDZH1.A 244.04,21.82 SDZH2.C
N$121
  Top 0.406: OK5X.2 183.51,29.21 182.4,30.33 VR41.1 178.11,33.81 LED9.C
N$122
  Top 0.406: OK3.2 221.62,29.84 221.13,30.33 VR42.1 216.21,33.81 LED10.C
N$123
  Top 0.406: SOK1.2 259.71,29.84 259.23,30.33 SRLOKD.1 251.46,34.14 SLED1.C
N$124
  Top 0.406: OK5X.1 180.97,27.94 182.25,26.67 182.25,23.5 181.61,22.86 181.61,17.14 180.34,15.88 VR46.2
N$125
  Top 0.406: OK3.1 220.34,26.98 220.34,23.5 219.71,22.86 219.71,17.14 218.44,15.88 VR44.2
N$126
  Top 0.406: SRHOKD.2 256.54,15.88 257.81,17.14 257.81,22.86 258.44,23.5 258.44,26.67 257.18,27.94 SOK1.1
N$127  (via drill 0.6)
  Top 0.406: U$7.1 98.36,28.83 v97.79,27.94 100.2,25.53 VR50.1 102.55,23.83 D17.C 102.82,21.54 102.11,20.83 102.11,19.81 TRIM9X.E
N$128
  Top 0.406: VR(+)10.1 87.25,23.77 VR47.1 87.12,23.9 87.12,22.61 86.61,22.1 83.57,22.1 83.19,21.72 TRIM10X.E
N$129
  Top 0.406: D18.C 106.05,23.38 D17.A 106.22,25.86 VR4.1
N$130
  Top 0.406: Q30.C 111.12,30.63 VR12.1
N$131  (1 unrouted)
N$132
  Top 0.406: Q30.B 112.33,33.66 112.39,33.02 112.39,27.56 115.06,27.56 115.57,27.05 115.57,25.4 116.2,24.77 116.2,24.13 116.59,23.37 VR54.2 | 118.75,23.5 118.42,23.37 | VR55.1 VR53.2
  Top 0.813: 118.42,23.37 116.59,23.37 | TRIM8X.S 118.75,23.5 VR53.2
N$133
  Top 0.406: 222.25,25.51 D40.A
  Top 0.813: 222.25,25.51 222.25,22.23 222.04,22.02 D39.C
N$134
  Top 0.406: Q36.B 226.38,34.61 226.69,33.02 226.69,27.56 229.36,27.56 229.87,27.05 229.87,25.4 230.5,24.77 230.5,24.19 VR72.2 | VR71.2 | VR71.2 VR73.1 | VR71.2
  Top 0.813: VR71.2 233.68,23.5 233.04,22.86 | 233.04,22.86 TRIM1-9.S | VR72.2 232.41,23.5 233.04,22.86
N$136
  Top 0.406: Q37.2 88.98,44.22 89.6,45.4 89.62,48.68 86.61,50.8 86.61,51.56 JP14.1
N$137
  Top 0.813: D23.C 241.09,21.82 D24.A
N$138  (via drill 0.5, 0.7)
  Top 0.406: v76.2,39.37 U$1.1 | VR45.2 74.76,46.67 VR80.2 76.54,46.77 v76.71,46.67
  Bottom 0.406: v76.71,46.67 78.99,45.47 78.99,41.66 v76.2,39.37
N$140
  Top 0.406: Q36.C 225.27,31.77 VR27.2
N$141
  Top 0.406: SROH.1 247.44,24.02 SDZH2.A
  Top 0.813: STRIM01.A 247.97,21.27 SROH.1
N$142
  Top 0.406: SDL2.C 256.54,25.51 256.54,23.5 SROL.1 255.91,23.18
  Top 0.813: 255.91,23.18 255.91,20.32 255.27,19.68 STRIM01.E
N$143
  Top 0.406: SQ1.B 245.43,33.98 245.75,33.02 245.75,27.56 248.41,27.56 248.92,27.05 248.92,25.4 249.56,24.77 249.56,23.5 SROH.2 | SRB.1 SROL.2
  Top 0.813: STRIM01.S 252.09,22.86 | 252.09,22.86 251.46,23.5 SROH.2 | SROL.2 252.73,23.5 252.09,22.86
N$144
  Top 0.406: SDL2.A 260.35,25.51 260.35,21.59 260.14,21.39 SDL1.C
N$145
  Top 0.406: SQ1.C 244.47,30.48 SRC.1
N$146
  Top 0.406: VR1.2 72.96,44.77 72.83,44.9 VR45.1 72.58,46.74 Q6.1
N$147
  Top 0.406: VR52.2 103.48,40.65 Q2.1
N$148
  Top 0.406: 105.03,76.83 107.44,75.18 107.44,43.94 106.51,43.01 Q2.3 | 105.03,76.83 104.9,76.96 103,76.96 K2.2 | D9A.A 105.78,77.58 105.03,76.83
N$149  (via drill 0.7)
  Top 0.305: IC2.3 85.63,47.79 v87,48.9 86.56,48.82 85.63,48.82
  Top 0.406: IC2.3 87.73,47.69 VR75.1 | 85.63,48.82 VR76.2
N$150  (1 unrouted)
N$151  (via drill 0.6)
  Top 0.406: U$7.4 102.11,31.3 102.49,30.92 v102.87,30.48 103.06,30.29 105.22,30.29 106.32,31.39 VR52.1
N$152  (3 unrouted)
N$153  (via drill 0.6)
  Top 0.406: U$7.6 98.04,32.26 v97.79,33.02 96.77,33.02 96.01,33.78 96.01,35.62 VR6.1 94.16,35.69 OK9X.4
N$154  (via drill 0.6)
  Top 0.406: U$7.3 102.42,28.32 v102.87,27.94 103.06,28.13 VR4.2
N$155  (1 unrouted)
N$156  (via drill 0.6)
  Top 0.406: 100.33,33.02 U$7.5 | v102.87,33.02 100.33,33.02 | VR5.2 95,26.5 D9A1.C 95.45,28.65 v97.03,30.23 | VR6.2 C1.1 100.52,33.59 100.33,33.02
  Bottom 0.406: v97.03,30.23 99.06,30.23 U$7.5 100.33,32.82 100.58,33.08 102.81,33.08 v102.87,33.02
N$157  (1 unrouted)
N$158  (1 unrouted)
N$159  (via drill 0.5)
  Top 0.406: v83.06,51.82 80.77,52.32 79.25,52.32 77.72,53.51 77.72,55.8 Q13.C | VR22.1 v87.63,35.75
  Bottom 0.406: v83.06,51.82 83.06,51.05 83.31,50.8 85.6,47.94 87.88,46.23 87.88,37.08 v87.63,35.75
N$160  (2 unrouted)
N$161  (2 unrouted)
N$162  (1 unrouted)
N$163
  Top 0.406: VR40.2 VR43.2
N$164
  Top 0.406: VR43.1 73.51,34.44 74.42,33.78 76.71,31.5 82.8,31.5 85.34,34.29 86.36,35.31 86.36,40.39 86.78,40.81 Q37.3
N$165  (via drill 0.7)
  Top 0.406: U$1.3 80.01,40.13 v81.28,39.37 80.61,38.19 VR79.1
N$166
  Top 1.016: D2.C 23.37,94.74 VCIN.+ | VQHV.E 30.86,109.6 | VCHI1.1 30.86,106.62 VCHI.1
  Bottom 1.016: Q45.E Q46.E 17.65,108.08 VRT4.2 18.03,107.19 24.13,101.09 24.13,100.84 | 24.13,100.84 24.13,96.77 23.37,96.01 23.37,94.74 VCIN.+ | VQHV.E 28.96,110.81 VCHI.1 31.56,103.69 28.7,100.84 24.13,100.84
N$167  (1 unrouted)
N$168  (via drill 0.5)  (1 unrouted)
  Top 0.406: VRB(-)10.1 75.44,35.73 75.44,34.54 76.71,33.27 81.28,33.27 82.46,34.96 VR77.1 83.57,36.32 v84.33,37.08 | Q(-)10.1 86.57,54.91 v86.17,54.93
  Bottom 0.406: v84.33,37.08 84.33,38.35 84.84,38.86 84.84,42.93 82.8,42.93 82.8,45.21 82.3,45.47 80.01,45.97 79.5,48.26 79.5,56.13 85.6,56.13 86.11,55.5 v86.17,54.93
N$169  (via drill 0.5)  (1 unrouted)
  Top 0.406: v87,57.02 87.04,56.98 Q(-)10.3 88.96,57.11 89.66,58.06 | VR80.1 76.45,49.28 76.39,49.34 v76.58,50.55 | D10A2.A 89.66,58.8 89.66,58.67
  Top 0.61: 89.66,58.06 89.66,58.67 89.6,88.46
  Top 0.813: K1.2 86.87,90.68 89.6,88.46
  Bottom 0.406: v87,57.02 80.52,57.15 78.74,56.9 78.74,53.09 v76.58,50.55
N$170  (via drill 0.5, 0.7)
  Top 0.406: U$1.6 v76.2,44.45 | v75.69,54.67 VR81.1
  Bottom 0.406: v76.2,44.45 74.68,44.45 73.91,45.21 73.91,52.32 74.93,52.45 74.93,53.09 v75.69,54.67
N$171  (2 unrouted)
N$172  (via drill 0.6)
  Top 0.406: D10A.C 74.18,22.85 v74.42,22.61 | v85.34,20.57 88.54,20.57 VR(+)10.2
  Bottom 0.406: v74.42,22.61 74.42,20.07 75.69,16.76 84.07,16.76 85.34,19.56 v85.34,20.57
OUT1  (via drill 0.6)
  Top 0.406: 34.29,31.06 V-TO1.3 | C-1083.2 37.1,33.66 V-TO1.3 | C-TO92.2 32.38,41.91 33.02,41.27 C-SO8.7 33.02,38.73 32.7,38.42 | 28.26,40.32 CRLM3.2 | 32.7,38.42 32.38,38.1 V-TO1.3 | 20.32,57.15 CMABDT.4 | CCIO1.2 CDZIO.A | 24.88,42.09 CRLM2.2 | 32.38,38.73 32.7,38.73 32.7,38.42
  Top 0.813: 32.38,38.73 31.75,38.73
  Top 1.27: 20.32,57.15 19.05,57.15 18.22,56.71
  Bottom 0.406: 14.86,49.02 14.61,50.8 | A..C.A 14.86,49.02 | C-TO92.2 32.38,41.85 33.02,40.9 35.5,40.9 | 38.8,45.66 39.43,46.29 | 14.86,49.02 CCIO1.2
  Bottom 1.27: 14.61,50.8 14.92,52.32 | 39.43,46.29 CQREG.C
  other vias: 26.04,58.42 23.5,58.42 23.5,55.88 26.04,55.88
  pour Top (hatched): 27.94,53.98 20.95,53.98 arc-90 19.05,52.07 arc-64 11.62,52.26 10.16,55.24 5.08,55.24 5.08,60.33 27.94,60.33
  pour Bottom (isolate 0.813, hatched): 43.18,34.29 41.91,34.29 39.37,36.83 39.37,37.47 38.73,38.1 34.29,38.1 37.47,40.64 38.1,41.27 38.1,43.81 39.37,45.09 40.64,45.72 40.45,47.18 31.62,47.18 arc74 27.43,43.5 27.43,33.72 arc33 38.1,29.84 38.73,29.84
  pour Top (isolate 0.813, rank 3, hatched): 11.43,52.77 20.32,52.7 20.95,45.09 24.13,42.55 32.38,41.91 39.37,34.92 38.73,30.48 38.73,23.5 30.48,23.5 29.84,26.67 22.86,31.11 14.61,34.29 12.06,36.83 12.13,50.86 12.06,51.63
  pour Bottom (rank 3): 27.94,53.98 20.95,47.62 17.14,43.81 12.7,43.81 12.7,49.53 10.79,53.34 5.08,53.34 5.08,60.33 27.94,60.33
  pour Bottom (rank 3): 38.73,26.04 38.73,23.5 30.48,23.5 30.48,26.67 38.1,26.67
OUT2  (via drill 0.6)
  Top 0.406: 25.4,66.67 25.34,66.67 V-SO8.7 | 24.47,73.53 VRT2.1 | VMABDT.4 v40.64,89.53
  Top 0.813: 25.4,66.67 TO92S.2 25.4,73.03 24.47,73.53 | VRT2.1 23.39,75.67 20.66,75.67 19.24,76.83 15.56,76.83 VRT1.2
  Top 1.27: 15.68,98.3 15.68,99.82
  Bottom 0.406: V-1083.2 41.48,74.03
  Bottom 1.27: V-1083.2 V-TO3.3 37.27,78.17 | 15.75,89.98 15.75,92.52
  other vias: 42.55,89.53 42.55,91.44 40.64,91.44
  pour Bottom (isolate 0.813, rank 6, hatched): 40.01,71.75 38.1,70.48 36.83,70.48 36.83,69.85 32.38,62.87 32.38,61.91 13.97,61.91 12.06,64.77 12.06,81.28 13.97,86.36 11.18,91.5 5.08,91.44 5.33,104.52 16.13,104.52 19.68,100.97 20.19,97.79 20.45,93.6 19.81,91.57 15.88,87 15.88,64.77 26.35,68.58 29.21,70.8 32.38,74.3 34.29,77.47 35.56,81.92 36.2,83.82 36.2,94.3 48.9,94.3 48.9,85.53 40.01,85.41
  pour Top (isolate 0.813, rank 2, hatched): 17.34,89.53 13.08,89.6 11.11,91.57 5.08,91.44 5.33,105.28 9.02,105.28 10.67,106.93 10.67,112.52 12.95,112.14 19.68,100.97 20.7,98.49 20.45,94.04 20.45,93.6 20.32,92.08
OUT+
  Top 0.406: A.C C..C C.C
  pour Bottom (isolate 0.813, rank 2, hatched): 11.43,43.81 5.08,43.81 5.08,53.98 9.53,53.98 11.43,50.16
PLUS11  (via drill 0.5, 0.6, 1.3)  (7 unrouted)
  Top 0.305: 83.38,50.29 83.12,50.42 83.04,50.09
  Top 0.406: FDZHV.C FCB.1 269.11,25.27 270.51,26.67 270.51,29.21 271.14,29.84 271.14,30.33 FQ1.E 270.82,30.8 271.78,31.75 271.78,33.02 272.42,33.66 272.42,36.83 273.05,37.47 273.05,38.58 FRIO.1 273.2,39.52 274.32,40.64 274.32,41.43 FRGS.1 273.84,45.14 FQFET.2 | VRT.1 88.24,98.81 74.42,98.81 70.74,99.69 67.31,89.15 67.31,11.18 70.36,8.13 70.61,8.13 70.87,7.87 | VR1.1 72.9,41.66 v72.64,40.89 | VR40.1 72.39,25.5 v72.14,25.15 | 83.38,50.29 84.33,51.31 83.82,53.59 Q(+)10.E | VR76.1 83.22,49.9 83.04,50.09 81.98,50.89 VR74.2 81.14,50.77 LED10X.A 76.96,53.11 76.96,55.61 Q13.E 75.25,56.45 v73.91,56.45
  Top 0.61: PLUS10+.1 v72.77,15.88 73.41,16.76 74.15,16.76 D10.C
  Top 0.813: PSR22.1 PCB.1 75.06,108.59 73.66,109.98 PSOK2.4
  Top 2.54: 273.84,45.14 280.04,50.86 280.04,81.92 271.14,87.63 v177.8,87.63
  Bottom 0.406: 183.6,104.84 S1.2 | (BATT+).1 PLUS10+.1 | 72.77,30.23 72.77,33.4 v72.64,40.89 72.9,40.39 72.9,39.37 | 72.77,30.23 v72.14,25.15 | v72.77,15.88 72.77,30.23 | v73.91,56.45 71.89,56.52 72.39,54.61
  Bottom 0.61: R2.2 73.32,10.33 71.37,8.38 71.37,8.64 (BATT+).1
  Bottom 1.422: 72.39,54.61 72.39,67.56
  Bottom 1.676: 72.39,67.56 K1.S | (BATT+).1 72.39,9.91 72.39,54.61
  Bottom 2.54: v177.8,87.63 177.8,100.97 180.91,104.84 183.6,104.84
Q0C  (via drill 1)
  Top 0.406: Q44.C 251.52,39.69 254.57,38.16 SRLOKD.2
  Top 0.61: Q23.4 251.42,53.3 v250.19,52.07
  other vias: 250.19,55.24 252.73,55.24 252.73,52.07
  pour Bottom (isolate 0.813, hatched): 260.35,69.85 260.35,47.62 251.46,43.18 242.57,47.62 242.57,69.85
  pour Top (isolate 0.61, rank 2): 259.08,62.87 259.08,49.53 242.57,49.53 242.57,82.55 252.73,82.55 252.73,78.74 245.11,78.74 245.11,62.87
Q2C  (via drill 1)
  Top 0.406: Q43.C 232.41,39.37 235.59,38.35 VR32.2
  Top 0.61: Q7.4 232.41,52.7 v231.14,51.44
  other vias: 233.68,55.24 231.14,55.24 233.68,51.44
  pour Bottom (isolate 0.813, hatched): 241.3,69.85 241.3,47.62 232.41,43.18 223.52,47.62 223.52,69.85
  pour Top (isolate 0.61, rank 2): 240.03,62.87 240.03,49.53 223.52,49.53 223.52,82.55 233.68,82.55 233.68,78.74 226.06,78.74 226.06,62.87
Q3C  (via drill 1)
  Top 0.406: Q42.C 213.36,39.37 216.53,38.23 VR42.2
  Top 0.61: Q24.4 213.36,53.98 v214.63,55.24
  other vias: 212.09,55.24 212.09,51.44 214.63,51.44
  pour Top (isolate 0.61, rank 2): 220.98,62.87 220.98,49.53 204.47,49.53 204.47,82.55 214.63,82.55 214.63,78.74 207.01,78.74 207.01,62.87
  pour Bottom (isolate 0.813, hatched): 222.25,69.85 222.25,47.62 213.36,43.18 204.47,47.62 204.47,69.85
Q4C  (via drill 1)
  Top 0.406: Q41.C 194.31,40.01 197.49,37.97 VR31.2
  Top 0.61: Q8.4 194.31,52.7 v193.04,51.44
  other vias: 195.58,55.24 193.04,55.24 195.58,51.44
  pour Top (isolate 0.61, rank 2): 201.93,62.87 201.93,49.53 185.42,49.53 185.42,82.55 195.58,82.55 195.58,78.74 187.96,78.74 187.96,62.87
  pour Bottom (isolate 0.813, hatched): 203.2,69.85 203.2,47.62 194.31,43.18 185.42,47.62 185.42,69.85
Q5C  (via drill 1)
  Top 0.406: Q40.C 175.26,40.01 178.44,37.91 VR41.2
  Top 0.61: Q25.4 175.26,52.7 v173.99,51.44
  other vias: 176.53,55.24 173.99,55.24 176.53,51.44
  pour Top (isolate 0.61, rank 2): 182.88,62.87 182.88,49.53 166.37,49.53 166.37,82.55 176.53,82.55 176.53,78.74 168.91,78.74 168.91,62.87
  pour Bottom (isolate 0.813, hatched): 184.15,69.85 184.15,47.62 175.26,43.18 166.37,47.62 166.37,69.85
Q6C  (via drill 1)
  Top 0.406: Q39.C 156.21,40.64 159.38,38.04 VR30.2
  Top 0.61: Q9.4 156.21,52.7 v154.94,51.44
  other vias: 157.48,55.24 154.94,55.24 157.48,51.44
  pour Top (isolate 0.61, rank 2): 163.83,62.87 163.83,49.53 147.32,49.53 147.32,82.55 157.48,82.55 157.48,78.74 149.86,78.74 149.86,62.87
  pour Bottom (isolate 0.813, hatched): 165.1,69.85 165.1,47.62 156.21,43.18 147.32,47.62 147.32,69.85
Q7C  (via drill 1)
  Top 0.406: Q38.C 137.16,40.01 140.34,37.97 VR37.2
  Top 0.61: Q20.4 137.16,52.7 v135.89,51.44
  other vias: 138.43,55.24 135.89,55.24 138.43,51.44
  pour Top (isolate 0.61, rank 2): 144.78,62.87 144.78,49.53 128.27,49.53 128.27,82.55 138.43,82.55 138.43,78.74 130.81,78.74 130.81,62.87
  pour Bottom (isolate 0.813, hatched): 146.05,69.85 146.05,47.62 137.16,43.18 128.27,47.62 128.27,69.85
Q8C  (via drill 1)  (1 unrouted)
  Top 0.406: Q21.C 118.11,40.64 121.28,38.1 VR29.2
  Top 0.61: Q3.4 118.11,52.7 v116.84,51.44
  other vias: 119.38,55.24 116.84,55.24 119.38,51.44
  pour Top (isolate 0.61, rank 2): 125.73,62.87 125.73,49.53 109.22,49.53 109.22,82.55 119.38,82.55 119.38,78.74 111.76,78.74 111.76,62.87
  pour Bottom (isolate 0.813, hatched): 127.64,69.85 127.64,47.62 118.75,43.18 109.86,47.62 109.86,69.85
Q9C  (via drill 1)
  Top 0.406: R3.1 98.83,80.26 93.98,80.26 91.95,77.47 92.2,67.82 92.29,67.91 Q2S.4 v100.97,66.29
  Top 1.27: VR24.2 98.93,43.56 99.82,44.45 Q2T.C
  other vias: 103.38,66.42 100.84,69.34
  pour Top (isolate 0.61, rank 2): 106.68,72.52 106.93,50.55 106.17,50.04 99.82,46.74 91.44,50.8 90.17,82.55 100.33,82.55 100.33,78.49 94.23,78.23 97.28,72.52
  pour Bottom (isolate 0.406, rank 2, hatched): 107.44,81.79 107.95,47.62 98.55,45.21 90.68,61.85 89.66,81.79
Q10C  (via drill 0.6)
  Top 0.406: Q6.3 73.53,50.93 72.64,51.82 72.64,52.7 VR14.2 72.77,54.65 VR81.2 72.49,55.26 72.52,57.28 72.68,57.44 VR13.2 73.28,60.2 78.74,60.2 Q1.C | Q10S.4 82.8,84.92 v82.8,85.09
  Bottom 0.406: v82.8,85.09 82.3,85.6 80.52,85.6
  Bottom 1.676: R2.1 80.52,85.6 80.52,63.25 Q1.C
V3  (via drill 0.7)
  Top 0.305: 80.33,48.62 80.33,46.16 81.03,45.21 81.28,44.96 v81.28,44.45
  Top 0.406: 78.74,44.45 U$1.5 | 78.74,44.45 v81.28,44.45 | D3.C 81.87,43.86 v81.28,44.45 | C2.1 73.15,38.86 74.93,40.64 74.93,42.93 74.68,43.18 74.68,45.47 78.74,45.47 78.74,44.45 | IC2.5 83.02,45.68 v81.28,44.45 | 80.33,48.62 VR74.1
V+OUT
  Top 0.406: FRBOUT.1 268.61,38.73 269.56,38.99 269.88,39.22 FRIO.2
  Top 0.813: FRFS.1 265.43,68.58 265.43,43.97 FRBOUT.1
  Bottom 0.406: VOUT(+)1.1 238.76,116.2 239.4,115.57
  Bottom 0.61: F2.2B 272.16,75.18 FRFS.1 269.62,75.56 F2.2A
  Bottom 2.54: PLUS120.1 238.89,115.06 239.4,115.57 241.3,117.47 271.14,117.47 276.86,111.76 276.86,89.53 271.78,84.45 FRFS.1
V-
  Top 0.813: VR-B.1 41.89,95.02 VCQ.B
  Top 1.778: VR-B.1 46.27,95.34 47.62,94.61 VRSHNT.1 47.62,66.67 45.72,64.77 VOUT-.1
  Bottom 2.54: S1.4 194.79,116.99 193.04,118.75 54.61,118.75 52.7,116.84 52.7,71.75 45.72,64.77 VOUT-.1 38.73,64.77 38.35,65.15 VCOUT.-
V_TOT
  Top 0.406: DRTRM.1 162.56,87.63 161.93,87 154.31,87 153.92,87.38 DTRIM.S
V_VENT
  Top 0.61: DQ1.2 123.19,108.08 123.04,107.92 DRTOP.1
  Top 0.813: P_L1.2 98.42,114.43 99.06,115.06 116.2,115.06 | 116.2,115.06 120.02,115.06 123.19,108.08 | 116.2,115.06 VENTILATOR.1
  Bottom 0.406: VENTILATOR.1 PCOUT.+
VENTB  (1 unrouted)
  Top 0.305: SOK1.3 259.71,35.12 | 260.99,83.19 260.99,37.53
  Top 0.406: 127.64,84.45 111.12,84.45 111.44,84.78 | 260.99,83.19 259.08,84.45 241.94,84.45 | 203.84,84.45 184.78,84.45 | 222.88,84.45 203.84,84.45 | 222.88,84.45 241.94,84.45 | 184.78,84.45 166.37,84.45 | 166.37,84.45 146.75,84.45 | 146.75,84.45 127.64,84.45 | 146.75,84.45 146.75,37.53 145.41,36.2 OK7.3 | OK6X.3 164.47,36.2 165.74,37.47 165.74,83.82 166.37,84.45 | 183.51,35.56 OK5X.3 183.51,36.2 184.78,37.47 184.78,84.45 | 202.56,35.56 OK4X.3 202.56,36.2 203.84,37.47 203.84,84.45 | 221.62,35.56 OK3.3 221.62,36.2 222.88,37.47 222.88,84.45 | 240.66,35.56 OK2X.3 240.66,36.2 241.94,37.47 241.94,84.45 | 260.99,37.53 260.99,37.47 259.71,36.2 SOK1.3 | 127.64,84.45 127.64,37.47 126.36,36.2 OK8X.3 | D10A1.C 86.95,26.85 86.87,27.43 86.87,33.53 88.14,34.54 88.58,34.54 | 88.58,34.54 VR23.1 | Q37.1 88.46,41.47 | 88.58,34.54 89.15,35.31 89.15,36.07 89.41,37.08 89.41,40.39 88.98,40.81 Q37.1 | Q37.1 VR22.2
  Top 0.813: 111.44,84.78 VQ1.1 110.95,90.97 109.86,92.08 109.86,98.4 | 109.86,98.4 P_Q2.1 | 109.86,98.4 107.62,98.4 VRB.1
VENTMID  (via drill 0.6)  (3 unrouted)
  Top 0.406: v106.93,83.19 107,83.5 107.63,82.55 | v125.73,83.19 126.68,82.55 126.68,37.97 126.17,37.47 125.09,37.47 123.83,36.2 OK8X.4 | v257.81,83.19 260.03,82.42 260.03,37.97 259.52,37.47 258.51,37.47 258.44,37.4 258.38,37.4 257.18,36.2 SOK1.4 | OK7.4 142.88,36.2 144.15,37.47 145.29,37.47 145.73,37.91 145.73,81.22 v144.65,82.55 | 161.93,35.56 OK6X.4 161.93,36.2 163.19,37.47 164.27,37.47 164.78,37.97 164.78,81.92 164.21,82.8 v164.21,82.55 | OK5X.4 180.97,36.2 182.25,37.47 183.32,37.47 183.83,37.97 183.83,81.28 v183.32,83.12 | 200.03,35.56 OK4X.4 200.03,36.2 201.23,37.4 202.31,37.4 202.88,37.97 202.88,81.28 v202.31,83.19 | 219.07,35.56 OK3.4 219.07,36.2 220.34,37.47 221.42,37.47 221.93,37.97 221.93,81.28 v221.36,83.19 | OK2X.4 238.12,36.2 239.4,37.47 240.47,37.47 240.98,37.97 240.98,81.28 v240.35,83.19
  Top 0.813: VRT.2 95,96.37 96.37,96.11 v97.28,94.74 VDZ1.C
  Bottom 0.406: 96.52,83.19 v106.93,83.19 v125.73,83.19 143.51,83.19 144.15,82.55 v144.65,82.55 146.05,83.19 163.19,83.19 163.83,82.55 v164.21,82.55 164.47,83.19 183.51,83.19 | 183.51,83.19 v202.31,83.19 v221.36,83.19 v240.35,83.19 v257.81,83.19 | 183.51,83.19 v183.32,83.12
VIN+  (via drill 1.3)
  Top 1.016: VRHV.2 26.42,109.12 VQHV.C 26.42,118.62 26.92,119.13 28.96,119.13 29.21,119.38
  Top 2.54: v193.68,91.44 180.97,91.44 177.8,94.61 177.8,111.76 175.26,118.87 29.21,119.38
  Bottom 2.54: S1.6 194.79,92.56 v193.68,91.44
VINX
  Top 1.016: VIN(+).1 27.81,103.76 25.65,105.92 | 25.65,105.92 23.51,105.92 D2.A | VIN+1.1 25.91,106.17 25.65,105.92
VIRT-
  Top 0.406: VD2.C 36.94,100.01 VD-S1.A
  Top 0.813: VCAD.- VD2.C 38.1,96.52 VCQ.C
  Bottom 0.813: VCIN.- 27.94,95.25 29.84,97.16 32.38,97.16 33.02,97.79 34.45,97.79 VCAD.-
  pour Top (rank 3): 38.73,103.5 38.73,95.89 36.83,95.89 34.29,97.79 36.2,99.69 37.47,103.5
  pour Bottom (isolate 0.813, rank 5): 34.04,99.44 34.92,99.06 34.92,93.34 25.15,92.84 25.15,96.27
VOUT+REG
  Bottom 2.54: S1.1 183.44,114.31 180.97,114.3 62.23,114.3 57.15,109.22 57.15,69.85 48.26,60.96 VOUT(+)REG.1
  pour Top (isolate 0.813, hatched): 44.45,59.69 40.01,59.69 35.56,60.96 34.29,61.59 32.38,61.91 13.97,61.91 arc-73 5.08,74.3 5.08,88.27 15.24,88.27 12.7,75.56 16.51,73.03 16.51,66.04 20.32,64.77 36.2,64.77 44.45,63.5
VSS  (via drill 0.5, 0.6, 0.7)  (3 unrouted)
  Top 0.406: U$1.2 v78.74,39.37 77.72,38.35 76.83,37.72 76.45,37.59 74.93,37.59 73.91,36.83 73.66,36.83 | M-10BAT.1 71.06,72.45 71.63,71.88 71.63,36.83 73.66,36.83 | 73.66,36.83 C2.2 | IC2.2 86.61,46.48 VR75.2 87.73,45.25 v86.68,44.45 85.6,43.43 85.6,41.4 84.84,40.64 v83.82,40.64 83.82,39.7 D3.A | VR(-)10.2 86.61,18.29 v87.12,18.8
  Bottom 0.406: 82.3,25.4 82.3,25.15 | 82.3,25.4 82.3,31.5 85.85,34.8 86.61,36.58 86.61,43.94 v86.68,44.45 | v78.74,39.37 78.99,37.59 82.55,37.59 v83.82,40.64 | v87.12,18.8 87.12,21.59 83.57,25.15 82.55,25.15 82.3,25.4
  Bottom 1.676: M-10BAT.1 72.77,72.77 76.2,76.2 76.33,76.2 K1.O

## Text on the board
Top: MICHAEL5.net | 25062012 | MICHAEL5.net | 25062012 | MICHAEL5.net | 25062012 | MICHAEL5.net
Bottom: MICHAEL5.net | MICHAEL5.net | MICHAEL5.net | 22062012
tNames: V_in(+)
tStop: MICHAEL5.net | MICHAEL5.net | MICHAEL5.net | MICHAEL5.net
tTest: V_out(+)