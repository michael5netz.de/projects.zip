# EAGLE board 01052013 (EAGLE 5.07), part 1 of 2

Size 285 x 125 mm. Coordinates in mm from the lower left corner, seen from the top.
Outline: 285,0 285,125 0,125 0,0 285,0
Copper layers (1*16): Top 0.035mm / dielectric 1.5mm / Bottom 0.035mm
Design rules "default *": minimum track width 10mil, minimum drill 24mil, track to track 8mil, track to pad 8mil, pad to pad 8mil, via to via 8mil, smd to smd 8mil, copper to edge 40mil, drill to drill 8mil, minimum pad ring 1mil, minimum via ring 8mil, stop-mask expansion 4mil, vias tented up to drill 0mil, thermal gap 10mil
Holes 3.2 mm at 3.17,3.17 46.99,50.8 3.17,50.8 46.99,3.17 3.17,120.65 48.26,109.86 212.72,120.65 279.4,120.65 279.4,3.17 66.04,29.21
Holes 2.5 mm at 137.79,29.84 119.38,29.84 156.84,29.84 176.53,29.84 194.94,29.84 214.63,29.84 233.68,29.84 252.73,29.84

## Footprints (pad centres in the part's own frame; a part is rotated, then mirrored left to right if it is on the bottom)
1X4MM5 = drill 4.5 pad 6.35 round: 1 0,0
1X01 = drill 1 pad 1.676 octagon: 1 0,0
TO220ACS = drill 1 pad 1.676 long: A 2.54,-2.54; C -2.54,-2.54
LED3MM = drill 0.8 pad 1.27 octagon: A -1.27,0; K 1.27,0
2KBP = drill 1 pad 1.676 long: + 5.715,0; - -5.715,0; AC1 -1.905,0; AC2 1.905,0
SOIC-4 = smd 1.27 x 2.54: + 1.3,3.685; - -1.3,3.685; ~1 -1.3,-3.685; ~2 1.3,-3.685
SMB = smd 2.4 x 2.4: A 2.2,0; C -2.2,0
C0805 = smd 1.3 x 1.5: 1 -0.95,0; 2 0.95,0
TO247S = drill 1.5 long: 1 -5.588,-2.921; 2 0,-2.921; 3 5.588,-2.921
SO08 = smd 0.6 x 2.2: 1 -1.905,-2.6; 2 -0.635,-2.6; 3 0.635,-2.6; 4 1.905,-2.6; 5 1.905,2.6; 6 0.635,2.6; 7 -0.635,2.6; 8 -1.905,2.6
TO92S = drill 0.6 pad 0.813 long: 1 -1.27,0; 2 0,0; 3 1.27,0
317TS = drill 1 long: 1 -2.54,-2.54; 2 0,-2.54; 3 2.54,-2.54
MINIMELF = smd 1.4 x 1.8: A 1.7,0; C -1.7,0
1X1MM8 = drill 1.6 pad 2.54 octagon: 1 0,0
C1206 = smd 1.6 x 1.8: 1 -1.4,0; 2 1.4,0
C050-025X075 = drill 0.8 pad 1.27 octagon: 1 -2.54,0; 2 2.54,0
E5-6 = drill 0.8 pad 1.905 round: + -2.54,0 | drill 0.8 pad 1.905 octagon: - 2.54,0
SOT23 = smd 1 x 1.4: 1 -0.95,-1.1; 2 0.95,-1.1; 3 0,1.1
DPACK = smd 1.6 x 3: 1 -2.28,-4.8; 3 2.28,-4.8 | smd 5.8 x 6.2: 4 0,2.38
R0805 = smd 1.3 x 1.5: 1 -0.95,0; 2 0.95,0
TO126AV = drill 1 pad 1.27 long: B 2.286,-1.27; C 0,-1.27; E -2.286,-1.27
R1206 = smd 1.6 x 1.803: 1 -1.422,0; 2 1.422,0
R5025 = smd 1.8 x 2.7: 1 -2.2,0; 2 2.2,0
R1210 = smd 1.6 x 2.7: 1 -1.4,0; 2 1.4,0
EVND8AA = drill 1 pad 1.778 long: A -2.5,-2.5; E 2.5,-2.5; S 0.04,2.54
SMC = smd 2.8 x 3.8: A 3.7,0; C -3.7,0
P-LCC-4-3 = smd 3.3 x 4.8: 1 -2,-3.15; 2 -2,3.15; 3 2,3.15; 4 2,-3.15
SOT223 = smd 1.219 x 2.235: 1 -2.311,-3.099; 2 0,-3.099; 3 2.311,-3.099 | smd 3.6 x 2.2: 4 0,3.099
SHK20Q = drill 1.3 pad 3.81 octagon: 1A -7.874,2.75; 1B -7.874,-2.75; 2A 7.874,2.75; 2B 7.874,-2.75
SOD80C = smd 1.4 x 1.8: A 1.7,0; C -1.7,0
SOT23-BEC = smd 1 x 1.4: B -0.95,-1.1; C 0,1.1; E 0.95,-1.1
TO252 = smd 1 x 1.6: 1 -2.28,-4.8; 2 2.28,-4.8 | smd 5.4 x 6.2: 3 0,2.5
0207/15 = drill 0.8 pad 1.27 octagon: 1 -7.62,0; 2 7.62,0
DIL8 = drill 0.8 long: 1 -3.81,-3.81; 2 -1.27,-3.81; 3 1.27,-3.81; 4 3.81,-3.81; 5 3.81,3.81; 6 1.27,3.81; 7 -1.27,3.81; 8 -3.81,3.81
SOT23-5 = smd 0.6 x 1.2: 1 -0.95,-1.306; 2 0,-1.306; 3 0.95,-1.306; 4 0.95,1.306; 5 -0.95,1.306
1X02 = drill 1.016 pad 1.676 long: 1 -1.27,0; 2 1.27,0
G2R = drill 1.2 pad 1.778 long: 1 -2.54,-3.683; 2 -2.54,3.81; O 13.97,-3.683; P 17.45,3.81; S 20.955,-3.683
L5650M = smd 1.8 x 4: 1 -2.5,0; 2 2.5,0
CHIPLED_1206 = smd 1.5 x 1.5: A 0,-1.75; C 0,1.75
SMD4 = smd 1.78 x 1.55: 1 -1.27,-3.5; 2 1.27,-3.5; 3 1.27,3.5; 4 -1.27,3.5
1X01' = drill 1 pad 1.27 square: 1 0,0
E2,5-6 = drill 0.8 pad 1.6 round: + -1.27,0 | drill 0.8 pad 1.6 octagon: - 1.27,0
SOT93V = drill 1.3 pad 1.676 long: B -5.461,-2.54; C 0,-2.54; E 5.461,-2.54
TO220AV = drill 1 pad 1.27 long: B -2.54,-2.54; C 0,-2.54; E 2.54,-2.54
D-PAK_TO252AA = smd 1 x 1.6: 1 -2.28,-4.8; 3 2.28,-4.8 | smd 5.4 x 6.2: 4 0,2.5
CERAM85 = drill 1 pad 2.54 octagon: 1 -42.5,0; 2 42.5,0
CERAM67 = drill 1 pad 2.54 octagon: 1 -33.5,0; 2 33.5,0
320NEW = drill 1.8 pad 3.81 octagon: 1 -4.928,7.823; 2 -4.928,0; 3 -4.928,-7.823; 4 4.928,7.823; 5 4.928,0; 6 4.928,-7.823
KSS1201 = drill 1 pad 2.159 octagon: + 3.251,0; - -3.251,0
S64W = drill 0.7 long: A 2.54,1.27; E -2.54,1.27; S 0,1.27
RANDL = drill 1 long: A -4,5; E 4,5; S 0,5 | drill 1 square: P$1 -5,-5; P$2 5,-5
SOT23-6 = smd 0.635 x 1.27: 1 -1.016,-1.016; 2 0,-1.016; 3 1.016,-1.016; 4 1.016,1.016; 5 0,1.016; 6 -1.016,1.016
TO3-K02 = drill 1.2 pad 3.81 octagon: 1 -1.778,-5.461; 2 -1.778,5.461 | drill 4.5 pad 6.477 round: 3 15.113,0; 3@ -15.113,0
E5-8,5 = drill 1 pad 2.54 round: + -2.54,0 | drill 1 pad 2.54 octagon: - 2.54,0
1X02' = drill 1 pad 1.27 square: 1 -1.27,0 | drill 1 pad 1.27 octagon: 2 1.27,0
0204V = drill 0.8 pad 1.27 octagon: 1 -1.27,0; 2 1.27,0
R0603 = smd 1 x 1.1: 1 -0.85,0; 2 0.85,0
0204/5 = drill 0.8 pad 1.27 octagon: 1 -2.54,0; 2 2.54,0
R2010 = smd 1.8 x 2.7: 1 -2.2,0; 2 2.2,0
0617/17 = drill 1 pad 1.676 octagon: 1 -8.89,0; 2 8.89,0
0207/10 = drill 0.813 octagon: 1 -5.08,0; 2 5.08,0

## Placement (x,y rotation side)
(BATT+)  [1X4MM5]  71.12,8.89 0 top
(BATT-)  [1X01]  261.62,15.88 0 top
A  [TO220ACS]  11.11,41.59 270 top
A..C  [LED3MM]  12.06,48.9 180 top
B1  [2KBP]  252.41,73.66 180 top
B2  [2KBP]  233.36,73.66 180 top
B3  MB1S  [SOIC-4]  252.09,66.04 180 top
B4  MB1S  [SOIC-4]  233.04,66.04 180 top
B5  [2KBP]  214.31,73.66 180 top
B6  MB1S  [SOIC-4]  214,66.04 180 top
B7  [2KBP]  195.26,73.66 180 top
B8  MB1S  [SOIC-4]  194.94,66.04 180 top
B9  [2KBP]  176.21,73.66 180 top
B10  MB1S  [SOIC-4]  175.9,66.04 180 top
B11  [2KBP]  157.16,73.66 180 top
B12  MB1S  [SOIC-4]  156.84,66.04 180 top
C  [SMB]  10.48,41.59 270 top
C1  [C0805]  101.47,35.69 0 top
C2  [C0805]  73.15,37.85 270 top
C-1083  LT1083CP-V  [TO247S]  44.45,33.66 270 top
C-SO8  [SO08]  32.38,43.18 180 top
C-TO92  [TO92S]  32.38,43.18 0 top
C-TS  [317TS]  44.07,33.66 270 top
C.  1N4148MINIMELF  [MINIMELF]  9.84,41.59 270 top
C_VIN+  [1X1MM8]  36.2,55.24 0 top
CCIO  [C1206]  21.59,48.9 180 top
CCIO1  [C050-025X075]  21.59,48.9 180 top
CCOUT  [E5-6]  34.92,22.86 270 top
CD4  BAS40-04  [SOT23]  12.13,31.5 180 top
CDT3L1  [MINIMELF]  7.62,34.29 90 top
CDT3L2  [MINIMELF]  10.16,34.29 90 top
CDZHV  1N4148MINIMELF  [MINIMELF]  36.89,50.86 270 top
CDZIO  [MINIMELF]  22.23,51.44 180 top
CHARGE  [1X01]  93.73,86.87 0 top
CMABDT  LM317MABDT  [DPACK]  26.99,57.15 90 top
CO1  [R0805]  38.99,57.91 270 top
CQHV  BD139  [TO126AV]  43.18,55.24 270 top
CQREG  BD139  [TO126AV]  43.12,46.55 270 top
CRHV  [R1206]  39.12,53.34 90 top
CRLM1  [R5025]  20.32,45.72 180 top
CRLM2  [R1210]  25.65,43.18 270 top
CRLM3  [R1206]  28.57,43.18 270 top
CRT2H  [R1206]  23.81,29.21 90 top
CTRIM2  [EVND8AA]  25.4,22.86 90 top
CTRIM3  [EVND8AA]  15.19,22.86 90 top
D1  [MINIMELF]  not placed on the board
D2  [SMC]  23.37,102.36 90 top
D3  [MINIMELF]  84.07,40.89 270 top
D9  [MINIMELF]  92.9,19.56 90 top
D9A  [MINIMELF]  104.08,80.71 0 top
D9A1  [MINIMELF]  93.98,30.35 90 top
D10  [MINIMELF]  74.49,16.76 90 top
D10A  [MINIMELF]  72.45,20.76 90 top
D10A1  [MINIMELF]  88.65,28.19 90 top
D10A2  [MINIMELF]  87.5,58.86 0 top
D12  [MINIMELF]  125.09,25.72 180 top
D13  [MINIMELF]  126.36,20.32 90 top
D14  [MINIMELF]  111.76,20.32 90 top
D15  [MINIMELF]  112.39,25.72 0 top
D17  [MINIMELF]  104.52,23.56 0 top
D18  [MINIMELF]  106.05,19.43 270 top
D19  [MINIMELF]  164.47,20.32 270 top
D20  [MINIMELF]  163.19,25.72 0 top
D21  [MINIMELF]  202.56,20.32 270 top
D22  [MINIMELF]  201.29,25.72 0 top
D23  [MINIMELF]  240.66,19.68 270 top
D24  [MINIMELF]  239.4,25.72 0 top
D25  [MINIMELF]  150.5,25.72 0 top
D26  [MINIMELF]  149.86,20.32 90 top
D27  [MINIMELF]  188.59,25.72 0 top
D28  [MINIMELF]  187.32,20.32 90 top
D29  [MINIMELF]  226.82,25.72 0 top
D30  [MINIMELF]  225.43,20.32 90 top
D33  [MINIMELF]  144.15,25.72 0 top
D34  [MINIMELF]  145.41,20.32 270 top
D35  [MINIMELF]  130.81,20.32 90 top
D36  [MINIMELF]  131.44,25.72 0 top
D37  [MINIMELF]  183.51,20.32 270 top
D38  [MINIMELF]  182.25,25.72 0 top
D39  [MINIMELF]  221.62,20.32 270 top
D40  [MINIMELF]  220.34,25.72 0 top
D43  [MINIMELF]  169.54,25.72 0 top
D44  [MINIMELF]  168.91,20.32 90 top
D45  [MINIMELF]  207.65,25.72 0 top
D46  [MINIMELF]  207.01,20.32 90 top
DCBLK1  [E5-6]  144.15,99.06 90 top
DCBLK2  [C1206]  148.72,97.41 90 top
DCMEAS  [C1206]  158.75,90.17 270 top
DDMEAS  [MINIMELF]  165.74,89.53 90 top
DDZ1  [MINIMELF]  124.46,101.09 180 top
DDZ2  [MINIMELF]  145.61,89.09 270 top
DDZ3  [MINIMELF]  143,91.76 270 top
DLED  [P-LCC-4-3]  135.89,97.16 0 top
DQ1  BCX56  [SOT223]  125.73,108.08 90 top
DRBLU  [R1206]  139.06,105.41 0 top
DRGRN  [R1206]  139.7,87.63 0 top
DRRED  [R1206]  133.99,87.63 0 top
DRTOP  [R1206]  124.46,103.63 0 top
DRTRM  [R1206]  162.56,89.53 90 top
DTRIM  [EVND8AA]  151.38,89.73 270 top
F2  [SHK20Q]  271.78,67.31 90 top
FCB  10n  [C1206]  268.61,26.67 90 top
FDZHV  [SOD80C]  268.61,20.95 270 top
FQ1  BC807-40SMD  [SOT23-BEC]  269.88,31.75 0 top
FQFET  FDD4141TO252  [TO252]  271.78,50.16 0 top
FQHVU  BC846  [SOT23]  273.05,27.3 0 top
FRBOUT  180k  [R1206]  267.97,37.47 270 top
FRFS  0  [0207/15]  271.78,67.94 270 top
FRGS  33k  [R1206]  272.42,41.91 180 top
FRGTE  120k  [R1206]  272.42,35.56 0 top
FRHVL  0.6/200u  [R1206]  272.42,22.86 0 top
FRHVT  14/3m  [R1206]  272.42,19.68 180 top
FRIO  270k  [R1206]  271.78,38.73 180 top
IC1  PIC12F675P  [DIL8]  156.84,98.42 0 top
IC2  LM321MF  [SOT23-5]  84.33,46.74 90 top
JP1  [1X01]  255.27,76.83 0 top
JP2  [1X01]  250.19,76.83 0 top
JP3  [1X01]  236.22,76.83 0 top
JP4  [1X01]  231.14,76.83 0 top
JP5  [1X01]  217.17,76.83 0 top
JP6  [1X01]  212.09,76.83 0 top
JP7  [1X01]  198.12,76.83 0 top
JP8  [1X01]  193.04,76.83 0 top
JP9  [1X01]  179.07,76.83 0 top
JP10  [1X01]  173.99,76.83 0 top
JP11  [1X01]  160.02,76.83 0 top
JP12  [1X01]  154.94,76.83 0 top
JP13  [1X01]  140.97,76.83 0 top
JP14  [1X02]  87.38,51.94 0 top
JP17  [1X02]  not placed on the board
K1  G2R  [G2R]  80.26,90.42 270 top
K2  G2R  [G2R]  99.06,74.3 270 top
L2  [L5650M]  92.08,109.98 270 top
LED4  [CHIPLED_1206]  156.21,35.56 180 top
LED5  [CHIPLED_1206]  194.31,35.56 180 top
LED6  [CHIPLED_1206]  232.41,35.56 180 top
LED7  [CHIPLED_1206]  137.16,35.56 180 top
LED8X  [CHIPLED_1206]  118.11,35.56 180 top
LED9  [CHIPLED_1206]  175.26,35.56 180 top
LED9X  [CHIPLED_1206]  98.81,39.12 270 top
LED10  [CHIPLED_1206]  213.36,35.56 180 top
LED10X  [CHIPLED_1206]  78.93,49.09 180 top
M-9BAT  [1X01]  100.33,8.26 0 top
M-10BAT  [1X01]  71.06,72.77 0 top
MINUS1-  [1X4MM5]  261.62,8.89 0 top
MINUS2-  [1X4MM5]  242.57,8.89 0 top
MINUS3-  [1X4MM5]  223.52,8.89 0 top
MINUS4-  [1X4MM5]  204.47,8.89 0 top
MINUS5-  [1X4MM5]  185.42,8.89 0 top
MINUS6-  [1X4MM5]  166.37,8.89 0 top
MINUS7-  [1X4MM5]  147.32,8.89 0 top
MINUS8-  [1X4MM5]  128.27,8.89 0 top
MINUS9-  [1X4MM5]  109.22,8.89 0 top
MINUS10  [1X4MM5]  90.17,8.89 0 top
MINUS60  [1X4MM5]  257.89,104.7 0 top
MINUS120  [1X4MM5]  219.89,104.7 0 top
OK2X  SFH6186-2  [SMD4]  239.4,31.75 0 top
OK3  SFH6186-2  [SMD4]  220.34,31.75 0 top
OK4X  SFH6186-2  [SMD4]  201.29,31.75 0 top
OK5X  SFH6186-2  [SMD4]  182.25,31.75 0 top
OK6X  SFH6186-2  [SMD4]  163.19,31.75 0 top
OK7  SFH6186-2  [SMD4]  144.15,31.75 0 top
OK8X  SFH6186-2  [SMD4]  125.09,31.75 0 top
OK9X  SFH6186-2  [SMD4]  92.71,39.05 180 top
OUT+  [1X01']  7.62,52.07 0 top
P_L1  [L5650M]  98.42,109.98 90 top
P_Q2  BCX56  [SOT223]  112.39,101.73 0 top
PCB  [C1206]  73.66,106.81 180 top
PCOUT  [E2,5-6]  106.05,109.98 270 top
PCT1  [C1206]  68.58,106.81 180 top
PDHOT  [SMB]  102.87,102.36 0 top
PLUS1+  [1X01]  242.57,15.88 0 top
PLUS2+  [1X01]  223.52,15.88 0 top
PLUS3+  [1X01]  204.47,15.88 0 top
PLUS4+  [1X01]  185.42,15.88 0 top
PLUS5+  [1X01]  166.37,15.88 0 top
PLUS6+  [1X01]  147.32,15.88 0 top
PLUS7+  [1X01]  128.27,15.88 0 top
PLUS8+  [1X01]  109.22,15.88 0 top
PLUS9+  [1X01]  90.17,15.88 0 top
PLUS10+  [1X01]  71.12,15.88 0 top
PLUS120  [1X4MM5]  238.89,104.7 0 top
PQ1  BC857  [SOT223]  93.98,102.36 270 top
PQ2  BC857  [SOT23-BEC]  86.36,102.36 270 top
PRE  [R1210]  76.83,101.73 0 top
PS16  [R1206]  69.22,111.25 270 top
PSOK2  SFH6186-2  [SMD4]  75.56,111.25 90 top
PSR22  [R1206]  78.74,106.81 0 top
PSR23  [R1206]  81.92,111.25 90 top
PZDFB  [MINIMELF]  85.72,111.25 270 top
Q1  TIP142SOT93V  [SOT93V]  80.26,65.53 0 top
Q1T  TIP120TO220V  [TO220AV]  80.26,65.53 0 top
Q2  BC847CSMD  [SOT23]  104.27,41.91 0 top
Q2S  TIP120  [D-PAK_TO252AA]  102.23,65.41 0 top
Q2T  TIP120TO220V  [TO220AV]  99.82,49.53 0 top
Q3  TIP120  [D-PAK_TO252AA]  118.11,50.8 0 top
Q4  BC857CSMD  [SOT23-BEC]  121.92,69.09 0 top
Q5  BC847CSMD  [SOT23]  88.39,55.82 0 top
Q6  BC847CSMD  [SOT23]  73.53,49.59 0 top
Q7  TIP120  [D-PAK_TO252AA]  232.41,50.8 0 top
Q8  TIP120  [D-PAK_TO252AA]  194.31,50.8 0 top
Q9  TIP120  [D-PAK_TO252AA]  156.21,50.8 0 top
Q10  BC857CSMD  [SOT23-BEC]  122.94,76.96 0 top
Q10S  TIP120  [D-PAK_TO252AA]  82.04,81.66 0 top
Q11  BC857CSMD  [SOT23-BEC]  not placed on the board
Q12  BC847ASMD  [SOT23]  not placed on the board
Q13  BC857CSMD  [SOT23-BEC]  77.22,57.4 270 top
Q14  BC857CSMD  [SOT23-BEC]  83.44,56.07 270 top
Q15  TIP120TO220V  [TO220AV]  118.11,44.45 0 top
Q16  TIP120TO220V  [TO220AV]  156.21,44.45 0 top
Q17  TIP120TO220V  [TO220AV]  194.31,44.45 0 top
Q18  TIP120TO220V  [TO220AV]  232.41,44.45 0 top
Q19  BC857CSMD  [SOT23-BEC]  91.95,24.89 180 top
Q20  TIP120  [D-PAK_TO252AA]  137.16,50.8 0 top
Q21  TIP142SOT93V  [SOT93V]  118.11,44.45 0 top
Q22  TIP120TO220V  [TO220AV]  137.16,44.45 0 top
Q23  TIP120  [D-PAK_TO252AA]  251.46,50.8 0 top
Q24  TIP120  [D-PAK_TO252AA]  213.36,50.8 0 top
Q25  TIP120  [D-PAK_TO252AA]  175.26,50.8 0 top
Q26  TIP120TO220V  [TO220AV]  175.26,44.45 0 top
Q27  TIP120TO220V  [TO220AV]  213.36,44.45 0 top
Q28  TIP120TO220V  [TO220AV]  251.46,44.45 0 top
Q29  TIP142SOT93V  [SOT93V]  99.82,49.53 0 top
Q30  BC857CSMD  [SOT23-BEC]  111.12,33.02 180 top
Q31  BC857CSMD  [SOT23-BEC]  130.18,33.02 180 top
Q32  BC857CSMD  [SOT23-BEC]  149.22,33.02 180 top
Q33  BC857CSMD  [SOT23-BEC]  168.28,33.02 180 top
Q34  BC857CSMD  [SOT23-BEC]  187.32,33.02 180 top
Q35  BC857CSMD  [SOT23-BEC]  206.38,33.02 180 top
Q36  BC857CSMD  [SOT23-BEC]  225.43,33.02 180 top
Q37  BC847CSMD  [SOT23]  87.88,42.42 90 top
Q38  TIP142SOT93V  [SOT93V]  137.16,44.45 0 top
Q39  TIP142SOT93V  [SOT93V]  156.21,44.45 0 top
Q40  TIP142SOT93V  [SOT93V]  175.26,44.45 0 top
Q41  TIP142SOT93V  [SOT93V]  194.31,44.45 0 top
Q42  TIP142SOT93V  [SOT93V]  213.36,44.45 0 top
Q43  TIP142SOT93V  [SOT93V]  232.41,44.45 0 top
Q44  TIP142SOT93V  [SOT93V]  251.46,44.45 0 top
Q45  TIP42C  [TO220AV]  12.19,114.05 0 top
Q46  TIP147  [SOT93V]  12.19,114.05 0 top
R2  [CERAM85]  80.52,53.59 270 bottom
R3  [CERAM67]  99.06,46.99 270 top
R4  [CERAM67]  118.11,46.99 270 top
R5  [CERAM67]  137.16,46.99 270 top
R13  [CERAM67]  175.26,46.99 270 top
R14  [CERAM67]  156.21,46.99 270 top
R16  [CERAM67]  194.31,46.99 270 top
R18  [CERAM67]  232.41,46.99 270 top
R21  [CERAM67]  213.36,46.99 270 top
R24  [CERAM67]  251.46,46.99 270 top
S1  [320NEW]  189.87,105.41 0 top
SDL1  [MINIMELF]  259.71,19.68 270 top
SDL2  [MINIMELF]  258.44,25.72 0 top
SDZH1  [MINIMELF]  244.47,19.68 90 top
SDZH2  [MINIMELF]  245.75,25.72 0 top
SLED1  [CHIPLED_1206]  251.46,35.56 180 top
SOK1  SFH6186-2  [SMD4]  258.44,31.75 0 top
SP1  KSS1201  [KSS1201]  168.28,98.14 270 top
SP2  KSS1201  [KSS1201]  116.59,-2.54 0 top
SP3  KSS1201  [KSS1201]  80.77,29.46 180 top
SQ1  BC857CSMD  [SOT23-BEC]  244.47,33.02 180 top
SRB  [R0805]  253.37,25.72 180 top
SRC  [R1206]  245.75,29.84 0 top
SRHOKD  [R1206]  247.65,15.88 0 top
SRLOKD  [R1206]  254.63,35.56 90 top
SROH  [R0805]  248.92,23.5 0 top
SROL  [R0805]  255.27,23.5 180 top
STRIM01  [S64W]  252.09,20.95 180 top
TO92S  [TO92S]  25.4,68.58 0 top
TRIM1-9  [S64W]  233.04,20.95 180 top
TRIM2-7  [S64W]  175.9,20.95 180 top
TRIM2-9  [S64W]  214,20.95 180 top
TRIM3-9  [S64W]  194.94,20.95 180 top
TRIM3X  [RANDL]  12.7,22.86 270 top
TRIM5X  [S64W]  156.84,20.95 180 top
TRIM7X  [S64W]  137.79,20.95 180 top
TRIM8X  [S64W]  118.75,20.95 180 top
TRIM9X  [S64W]  99.69,20.95 180 top
TRIM10X  [S64W]  80.64,21.59 180 top
TRIM10X1  [S64W]  80.64,15.75 180 top
U$1  PIC10F204OT  [SOT23-6]  78.74,42.04 0 top
U$2  PIC10F204OT  [SOT23-6]  153.03,98.42 180 top
U$7  PIC10F204OT  [SOT23-6]  100.33,30.48 0 top
V-1083  LT1083CP-V  [TO247S]  44.83,73.98 270 top
V-SO8  [SO08]  25.4,68.58 180 top
V-TO1  [TO3-K02]  26.3,44.45 225 bottom
V-TO3  [TO3-K02]  26.4,84.72 225 bottom
V-TS  [317TS]  44.45,73.98 270 top
VCAD  [E2,5-6]  34.51,96.46 90 top
VCHI  [C050-025X075]  33.85,106.17 0 top
VCHI1  [C1206]  32.26,108.71 0 top
VCIN  [E2,5-6]  24.51,93.85 0 top
VCIO  [C1206]  16.38,87.5 180 top
VCLO  [C050-025X075]  38.1,111.19 0 top
VCLO1  [C1206]  37.34,108.71 0 top
VCOUT  [E5-8,5]  34.29,65.15 0 top
VCQ  BC817-40LT1SMD  [SOT23-BEC]  39.5,96.01 90 top
VD2  [MINIMELF]  38.93,99.06 0 top
VD-S1  [MINIMELF]  36.39,102.81 0 top
VD-S2  [MINIMELF]  32,98.11 90 top
VDIO  [MINIMELF]  19.68,90.23 180 top
VDZ1  [MINIMELF]  100.46,96.9 0 top
VENTILATOR  [1X02']  116.2,109.98 270 top
VFUSE  [SHK20Q]  8.89,94.61 90 top
VIN(+)  [1X1MM8]  27.94,103.76 270 top
VIN(-)  [1X01']  41.91,104.14 270 top
VIN(-)1  [1X01']  31.75,17.78 270 top
VIN+1  [1X01']  27.94,106.17 270 top
VMABDT  LM317MABDT  [DPACK]  38.99,90.49 270 top
VMINUS(-)  [1X1MM8]  47.62,104.14 0 top
VO1  [0204V]  27.69,80.64 270 top
VO2  [0204V]  20.13,64.9 180 top
VOUT(+)  [1X01]  7.62,48.26 270 top
VOUT(+)1  [1X01]  238.76,117.47 0 top
VOUT(+)REG  [1X01]  41.91,60.96 270 top
VOUT-  [1X01]  41.91,64.77 180 top
VPOT1  [RANDL]  12.7,70.8 270 top
VPOT2  [S64W]  16.45,70.8 270 top
VQ1  BC847  [SOT23]  112.39,92.08 0 top
VQHV  TIP41C  [TO220AV]  26.42,114.05 0 top
VR1  [R0603]  72.96,43.43 90 top
VR2  [R0603]  74.55,21.15 270 top
VR3  [0204/5]  29.53,96.58 270 top
VR3X  [R1206]  29.53,96.52 270 top
VR4  [R0805]  105.85,27.18 90 top
VR5  [R1206]  95.31,24.89 90 top
VR6  [R0805]  97.03,35.69 0 top
VR7  [R1206]  not placed on the board
VR8  [R1206]  not placed on the board
VR8X  [0204V]  33.66,86.04 180 top
VR9  [R1206]  not placed on the board
VR10  [R1206]  123.44,64.01 0 top
VR11  [R0603]  80.58,58.99 180 top
VR12  [R1206]  112.39,29.84 0 top
VR13  [R0603]  73.53,58.36 180 top
VR14  [R0805]  73.72,52.83 180 top
VR15  [R0805]  96.46,42.55 90 top
VR16  [R1206]  116.08,64.26 0 top
VR17  [R1206]  117.09,73.15 0 top
VR18  [R1206]  88.9,22.35 270 top
VR19  [R1206]  86.87,17.02 90 top
VR20  [R1206]  131.44,29.84 0 top
VR21  [R1206]  93.22,83.69 0 top
VR22  [R0603]  88.14,38.61 90 top
VR23  [R0603]  88.65,33.53 270 top
VR24  [R0805]  98.93,42.55 90 top
VR25  [R1206]  150.5,29.84 0 top
VR26  [R1206]  188.59,29.84 0 top
VR27  [R1206]  226.69,29.84 180 top
VR28  [R1206]  114.3,15.88 0 top
VR29  [R1206]  121.28,35.56 90 top
VR30  [R1206]  159.38,35.56 90 top
VR31  [R1206]  197.49,35.56 90 top
VR32  [R1206]  235.59,35.56 90 top
VR33  [R1206]  190.5,15.88 0 top
VR34  [R1206]  228.6,15.88 0 top
VR35  [R1206]  152.4,15.88 0 top
VR36  [R1206]  133.35,15.88 0 top
VR37  [R1206]  140.34,35.56 90 top
VR38  [R1206]  169.54,29.84 0 top
VR39  [R1206]  207.65,29.84 0 top
VR40  [R1206]  72.9,28 90 top
VR41  [R1206]  178.44,35.56 90 top
VR42  [R1206]  216.53,35.56 90 top
VR43  [R1206]  72.9,33.02 270 top
VR44  [R1206]  209.55,15.88 0 top
VR45  [R0603]  73.66,46.74 0 top
VR46  [R1206]  171.45,15.88 0 top
VR47  [R0603]  86.23,23.94 180 top
VR48  [R0603]  74.93,24.38 180 top
VR49  [R0603]  79.63,54.74 270 top
VR50  [R0805]  100.46,24.45 270 top
VR51  [R0805]  97.73,24.45 90 top
VR52  [R1206]  104.9,38.16 180 top
VR53  [R0805]  121.92,23.5 180 top
VR54  [R0805]  115.57,23.5 0 top
VR55  [R0805]  120.02,25.72 180 top
VR56  [R0805]  140.97,23.5 180 top
VR57  [R0805]  134.62,23.5 0 top
VR58  [R0805]  139.06,25.72 180 top
VR59  [R0805]  160.02,23.5 180 top
VR60  [R0805]  153.67,23.5 0 top
VR61  [R0805]  158.12,25.72 180 top
VR62  [R0805]  179.07,23.5 180 top
VR63  [R0805]  172.72,23.5 0 top
VR64  [R0805]  177.16,25.72 180 top
VR65  [R0805]  198.12,23.5 180 top
VR66  [R0805]  191.77,23.5 0 top
VR67  [R0805]  196.22,25.72 180 top
VR68  [R0805]  217.17,23.5 180 top
VR69  [R0805]  210.82,23.5 0 top
VR70  [R0805]  215.26,25.72 180 top
VR71  [R0805]  236.22,23.5 180 top
VR72  [R0805]  229.87,23.5 0 top
VR73  [R0805]  234.31,25.72 180 top
VR74  [R0603]  80.84,50.04 90 top
VR75  [R0603]  87.88,46.67 270 top
VR76  [R0603]  83.95,49.15 0 top
VR77  [R0603]  82.3,36.32 180 top
VR78  [R0603]  75.95,35.81 0 top
VR79  [R0603]  78.99,36.58 180 top
VR80  [R0603]  76.33,48.58 270 top
VR81  [R0603]  73.53,54.67 180 top
VR-B  [R2010]  43.31,97.54 90 top
VRB  [R1206]  107.31,97.28 270 top
VRB1  [R1206]  34.48,84.01 180 top
VRB2  [R1206]  21.59,69.85 90 top
VRHV  [R1206]  25.15,108.97 0 top
VRSHNT  [0617/17]  47.62,91.44 90 top
VRT  [R1206]  92.08,96.39 0 top
VRT1  390  [0207/15]  22.86,77.15 180 top
VRT2  [R1206]  22.86,73.66 180 top
VRT3  [R1206]  13.34,80.64 0 top
VRT4  390  [0207/10]  12.95,107.7 0 top
VTRIM1  [EVND8AA]  27.62,81.92 90 top
VZDHV  [MINIMELF]  16.7,104.78 180 top

## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via)
ADJ2  (via drill 1)
  Top 0.406: 23.5,69.85 V-SO8.4 23.05,71.27 | VMABDT.1 34.55,92.37 | V-TO3.2 20.95,81.92
  Top 0.813: 23.5,69.85 TO92S.1 | 23.05,71.27 VRB2.2 20.47,71.27 19.68,70.48 18.02,70.48 VPOT1.S | 34.55,92.37 VCAD.+
  Top 1.27: v23.64,84.01 V-TO3.2
  Bottom 0.406: 41.18,79.92 V-1083.1 V-TS.1 | 41.18,79.92 40.64,80.45 | 41.18,79.92 41.91,80.64 v41.91,82.23 42.55,82.55 | V-TO3.2 21.28,81.95 VTRIM1.S 25.12,81.92 VO1.1
  Bottom 0.813: VPOT1.S VPOT2.S 18.73,70.8 19.62,71.06
  Bottom 1.27: 19.62,71.06 arc30 23.5,81.28 v23.64,84.01
  pour Bottom (isolate 0.813, hatched): 40.64,84.45 44.45,84.45 44.45,76.83 43.18,75.56 40.64,75.56
  pour Top (isolate 0.813, hatched): 44.45,85.09 44.45,76.83 43.81,76.2 41.27,76.2 40.64,76.83 arc77 33.66,79.38 24.77,81.92 35.56,83.82 35.56,89.53 34.29,90.81 34.61,95.89 38.1,93.98 38.1,86.36 40.01,85.09
  pour Bottom (isolate 0.813, rank 2): 31.75,94.61 35.56,93.34 35.56,95.89 33.02,95.89
ADJUST  (via drill 0.6, 1)
  Top 0.406: 28.8,44.83 CRLM3.1 | V-TO1.2 20.49,41.91 v18.99,39.69 19.68,38.73 | 30.48,44.45 C-SO8.4 | 30.48,43.18 30.48,44.45 | 10.89,39.3 10.25,39.3 C.A | C.A C..A A.A 7.62,38.73 CDT3L1.A | 30.48,44.45 29.84,44.45 | 30.48,43.18 30.48,41.27 | C-TO92.1 30.48,43.18 | CD4.1 13.06,33.99 12.06,34.92 12.06,37.47 10.79,38.73 10.79,38.76 C.A
  Top 0.61: CQREG.E 41.78,48.9 39.37,48.9 39.1,49.16 CDZHV.A
  Top 0.813: C-1083.1 36.9,42.49 CDZHV.A 34.92,50.16 34.92,52.7 32.76,54.87 CMABDT.1
  Top 1.016: 28.8,44.83 29.84,44.83 29.84,44.45
  Top 1.27: v30.48,35.88 29.59,36.07 arc-33 19.68,38.73
  Bottom 0.406: C-1083.1 40.77,40.01 | 30.99,41.47 C-TO92.1
  Bottom 0.813: 30.99,38.16 30.99,41.47
  Bottom 1.27: C-TS.1 C-1083.1 40.64,39.37 38.73,39.37 arc37 31.18,36.96 30.99,36.77 | v30.48,35.88 30.48,36.26 30.99,36.77 | 30.99,36.77 30.99,38.16
  pour Bottom (isolate 0.813, hatched): 20.95,40.01 arc-90 19.05,38.1 5.71,38.1 5.08,39.37 5.08,41.27 6.35,42.55 12.06,42.55 12.7,43.18 20.95,43.18
  pour Top (isolate 0.61): 31.11,46.99 22.23,46.99 22.23,44.45 29.84,43.81 30.48,43.18 31.11,43.18
B  (via drill 0.5, 0.7)
  Top 0.406: 80.64,21.97 80.64,22.48 82.3,24.13 85.19,24.13 VR47.2 | 80.64,21.97 TRIM10X.S | 80.64,21.97 79.25,24.38 VR48.1 | v82.3,53.34 82.3,53.44 | v84.45,44.45 85.09,45.24 IC2.1 | VR49.2 80.54,53.38 v82.3,53.34 | Q14.B 82.42,57.02 80.9,57.02 80.9,53.34 v82.3,53.34
  Bottom 0.406: TRIM10X.S 80.64,24.77 80.26,31.24 80.26,33.53 80.77,33.78 82.04,33.78 85.6,36.32 85.6,43.43 v84.45,44.45 84.45,46.86 81.53,50.04 81.53,52.32 v82.3,53.34
B1
  Bottom 0.406: 43.81,16.51 45.34,17.59 45.34,42.99 43.81,43.81 43.43,43.81 CQREG.B
  Bottom 0.61: 43.81,16.51 34.92,16.51 33.66,15.24 29.21,15.24 27.94,16.51 15.24,16.51 12.7,19.05 CTRIM3.S TRIM3X.S
B2  (via drill 0.7)
  Top 0.406: VR77.2 82.13,37.76 82.55,38.35 82.55,40.39 v81.28,41.91 81.28,42.16 80.77,42.67 U$1.4
  Bottom 0.406: v81.28,41.91 81.28,42.16
B-Q1
  Top 0.406: FCB.2 268.61,30.33 FQ1.B 267.33,32.24 267.33,34.29 267.97,34.92 FRBOUT.2
BATT-  (via drill 0.6)  (3 unrouted)
  Top 0.406: v274.64,31.11 274.95,30.48 274.95,27.3 274,26.35 FQHVU.2 274,23.02 FRHVL.2 | DTRIM.A 154.16,92.22 154.31,92.08 156.21,92.08 156.84,91.44 156.84,90.17 157.99,89.53 DCMEAS.2 | OK9X.2 91.44,41.91
  Top 0.61: IC1.8 U$2.2 | DCBLK2.2 148.72,100.84 147.96,101.6 DCBLK1.-
  Top 0.813: PCT1.2 67.31,106.94 67.31,108.71 68.58,109.98 69.06,109.98 PS16.2 | VQ1.2 v115.57,90.93 | PDHOT.A 106.05,104.01 PCOUT.- | VRB.2 104.62,95.86 v103.5,96.77 VDZ1.A | SDL1.A 259.71,12.06 MINUS1-.1 | P_Q2.3 114.71,97.51 115.57,92.08 v115.57,90.93 | DDZ1.A 122.76,88.47 121.28,90.81 115.7,90.81 v115.57,90.93
  Top 1.27: 253.52,62.23 B3.-
  Top 1.422: B1.- 258.13,71.44 256.54,69.85 256.54,64.14 254.63,62.23 253.52,62.23
  Bottom 0.406: 103,90.04 v103.5,96.77 | PCOUT.- 107.31,101.73 | 150.5,102.23 IC1.8 153.03,100.33 153.67,99.69 165.1,99.69 166.8,101.4 SP1.- | 150.5,102.23 150.5,95.89 148.88,94.27 DTRIM.A | 150.5,102.23 147.32,102.23 DCBLK1.- 145.41,101.6 144.15,100.33 | 264.8,31.11 v274.64,31.11
  Bottom 0.813: 264.8,84.45 260.99,84.45 260.35,85.09 180.97,85.09 180.34,84.45 168.91,84.45
  Bottom 1.27: 262.25,10.16 (BATT-).1 | B1.- 261,73.64 261.62,73.03 | 259.08,39.12 259.33,39.37
  Bottom 1.422: Q44.E Q28.E | 261.62,47.62 261.62,73.03
  Bottom 1.778: 259.33,39.37 259.33,39.5 Q44.E
  Bottom 2.54: S1.5 201.29,105.41 212.72,91.44 256.54,91.44 | MINUS60.1 257.89,102.95 256.54,100.97 256.54,91.44 | 256.54,91.44 264.8,84.45 264.8,31.11 264.8,17.14 262.25,10.16 | 262.25,10.16 MINUS1-.1 259.08,15.24 259.08,39.12 | 262.25,10.16 262.25,11.43 261.62,12.06 261.62,47.62
  pour Top (isolate 0.813): 253.37,46.99 257.18,46.99 259.08,44.45 259.08,38.73 254,38.73 253.37,44.45
  pour Bottom (isolate 0.813, rank 2, hatched): 66.04,109.35 66.04,90.55 126.62,90.3 170.43,84.2 172.09,87.63 172.09,106.05 170.18,107.31 68.58,111.89
CVIN
  Top 0.61: CRHV.2 38.63,55.24 C_VIN+.1
  Top 0.813: CQHV.C 42.39,55.4 CRHV.2 38.73,56.03 CO1.2
  Bottom 1.778: C_VIN+.1 CQHV.C
D
  Top 1.27: F2.1B 272.03,58.17 FRFS.2 | FQFET.3 FRFS.2 | FRFS.2 269.49,58.42 F2.1A
E2  (via drill 0.6)
  Top 0.406: 244.47,15.88 SRHOKD.1 | SQ1.E 243.53,35.88 v243.84,36.2 | v248.92,36.2 SLED1.A
  Top 0.813: SDZH1.C 244.47,15.88 244.47,12.7 MINUS2-.1 240.66,12.7 D23.A
  Top 1.27: 250.67,62.23 B3.+ | B4.- 234.47,62.23 235.59,62.23
  Top 1.422: B1.+ 246.7,71.44 247.65,70.48 247.65,64.14 249.56,62.23 250.67,62.23 | 235.59,62.23 237.49,64.14 237.49,69.85 239.08,71.44 B2.-
  Bottom 0.406: 242.57,36.2 v243.84,36.2 v248.92,36.2
  Bottom 1.27: 242.57,73.66 B2.-
  Bottom 1.422: Q43.E Q18.E
  Bottom 1.778: B1.+ 243.21,73.66 242.57,73.03
  Bottom 2.54: MINUS2-.1 PLUS1+.1 242.57,36.2 242.57,73.03 242.57,73.66 | Q43.E 238.12,41.91 240.03,40.01 240.03,11.43 MINUS2-.1 | R24.2 247.17,13.49 MINUS2-.1
  pour Top (isolate 0.813): 234.31,46.99 238.12,46.99 240.03,44.45 239.4,38.73 234.95,38.73 234.31,44.45
E3  (via drill 0.6)
  Top 0.406: 225.43,15.88 VR34.1 | v229.87,36.2 LED6.A
  Top 0.61: Q36.E 224.47,35.88 v224.79,36.2
  Top 0.813: D39.A 221.62,12.06 222.25,10.79 MINUS3-.1 225.43,10.79 225.43,15.88 D30.C
  Top 1.27: B6.- 215.42,62.23 216.53,62.23
  Top 1.422: 216.53,62.23 218.44,64.14 218.44,69.85 220.09,71.5 220.03,71.56 B5.- | B4.+ 231.62,62.23 230.5,62.23 228.6,64.14 228.6,70.48 227.65,71.44 B2.+
  Bottom 0.406: v224.79,36.2 v229.87,36.2
  Bottom 0.61: v224.79,36.2 224.16,36.2 | PLUS2+.1 223.2,15.56
  Bottom 1.27: MINUS3-.1 PLUS2+.1 224.16,12.06 224.16,36.2 224.16,73.66 B2.+
  Bottom 1.422: Q42.E Q27.E | MINUS3-.1 223.52,15.24 223.2,15.56 222.88,13.97 222.88,73.66 B5.-
  Bottom 1.778: 220.98,40.01 220.73,40.01 Q42.E
  Bottom 2.54: 220.98,40.01 220.98,15.24 MINUS3-.1 228.12,13.49 R18.2
  pour Top (isolate 0.813): 215.26,46.99 219.07,46.99 220.98,44.45 220.34,38.73 215.9,38.73 215.26,44.45
E4  (via drill 0.6)
  Top 0.406: v210.82,36.2 LED10.A | 206.38,15.88 VR44.1
  Top 0.61: Q35.E 205.43,35.88 v205.74,36.2
  Top 0.813: D46.C 207.01,18.41 206.38,17.78 206.38,15.88 206.38,12.06 MINUS4-.1 202.56,12.7 D21.A
  Top 1.27: B8.- 196.37,62.23 197.49,62.23
  Top 1.422: 197.49,62.23 199.39,64.14 199.39,69.85 200.98,71.44 B7.- | B6.+ 212.57,62.23 211.46,62.23 209.55,64.14 209.55,70.48 208.6,71.44 B5.+
  Bottom 0.406: 204.47,13.34 205.1,12.06 | v205.74,36.2 v210.82,36.2
  Bottom 0.61: 205.1,36.2 v205.74,36.2
  Bottom 1.27: MINUS4-.1 204.47,13.34 PLUS3+.1
  Bottom 1.422: Q41.E Q17.E | B5.+ 205.1,73.66 205.1,36.2 205.1,12.06 | 203.84,12.7 203.84,73.66 B7.-
  Bottom 1.778: 201.93,40.01 201.68,40.01 Q41.E
  Bottom 2.54: 201.93,40.01 201.93,11.43 203.84,9.53 203.84,12.7 MINUS4-.1 209.07,13.49 R21.2
  pour Top (isolate 0.813): 196.22,46.99 200.03,46.99 201.93,44.45 201.29,38.73 196.85,38.73 196.22,44.45
E5  (via drill 0.6)
  Top 0.406: 185.42,12.06 185.42,11.43 MINUS5-.1 | v192.41,36.2 LED5.A | Q34.E 186.37,35.71 v186.69,36.2 | 187.32,15.88 VR33.1
  Top 0.813: 185.42,12.06 187.32,13.65 187.32,15.88 D28.C | D37.A 183.51,13.34 185.42,11.43
  Top 1.27: B9.- 181.93,71.44 | 189.55,71.44 B7.+
  Top 1.422: 181.93,71.44 180.34,69.85 180.34,64.14 178.44,62.23 178.31,62.35 B10.- | B8.+ 193.52,62.23 192.41,62.23 190.5,64.14 190.5,70.48 189.55,71.44
  Bottom 0.406: v192.41,36.2 v186.69,36.2 185.42,36.2
  Bottom 1.27: MINUS5-.1 185.42,10.16 PLUS4+.1
  Bottom 1.422: Q40.E Q26.E
  Bottom 1.778: 182.88,40.01 182.63,40.01 Q40.E
  Bottom 2.54: 182.88,40.01 182.88,15.24 MINUS5-.1 190.02,13.49 R16.2 | B9.- 184.78,73.66 185.42,73.03 | 185.42,73.03 185.42,36.2 185.42,10.16 | 185.42,73.03 186.06,73.66 B7.+
  pour Top (isolate 0.813): 177.16,46.99 180.97,46.99 182.88,44.45 182.25,38.73 177.8,38.73 177.16,44.45
E6  (via drill 0.6)
  Top 0.406: v173.35,36.2 LED9.A
  Top 0.61: 168.28,15.88 VR46.1 | Q33.E 168.59,35.88 v168.28,36.2 | 164.47,11.43 165.1,10.16 MINUS6-.1
  Top 0.813: D44.C 168.28,15.88 168.28,12.7 MINUS6-.1 | 164.47,11.43 D19.A
  Top 1.422: B12.- 158.27,62.23 159.38,62.23 161.29,64.14 161.29,69.85 162.88,71.44 B11.- | B10.+ 174.47,62.23 173.35,62.23 171.45,64.14 171.45,70.48 170.5,71.44 B9.+
  Bottom 0.406: v168.28,36.2 v173.35,36.2
  Bottom 0.61: 167,36.2 v168.28,36.2 | PLUS5+.1 167,11.43
  Bottom 1.27: MINUS6-.1 PLUS5+.1
  Bottom 1.422: Q39.E Q16.E | B9.+ 167,73.66 167,36.2 167,11.43 165.74,13.97 165.74,73.66 B11.-
  Bottom 1.778: 163.83,40.01 163.58,40.01 Q39.E
  Bottom 2.54: 163.83,40.01 163.83,15.24 MINUS6-.1 170.97,13.49 R13.2
  pour Top (isolate 0.813): 158.12,46.99 161.93,46.99 163.83,44.45 163.19,38.73 158.75,38.73 158.12,44.45
E7  (via drill 0.6)
  Top 0.406: 149.22,15.88 VR35.1 | v154.31,36.2 LED4.A
  Top 0.61: Q32.E 148.28,35.88 v148.59,36.2 | 146.05,9.53 MINUS7-.1
  Top 0.813: D34.A 145.41,11.43 146.05,9.53 | D26.C 149.22,15.88 149.22,11.43 MINUS7-.1
  Top 1.422: B12.+ 155.42,62.23 154.31,62.23 152.4,64.14 152.4,70.48 151.45,71.44 B11.+
  Bottom 0.406: v148.59,36.2 v154.31,36.2
  Bottom 0.61: 147.96,35.56 v148.59,36.2
  Bottom 1.27: MINUS7-.1 PLUS6+.1
  Bottom 1.422: Q38.E Q22.E | B11.+ 147.96,73.66 147.96,35.56 147.96,12.06 PLUS6+.1 146.69,14.61 146.69,73.66
  Bottom 1.778: 144.78,40.01 144.53,40.01 Q38.E
  Bottom 2.54: 144.78,40.01 144.78,15.24 MINUS7-.1 151.92,13.49 R14.2
  pour Top (isolate 0.813): 139.06,46.99 142.88,46.99 144.78,44.45 144.15,38.73 139.7,38.73 139.06,44.45
E8  (via drill 0.6)  (4 unrouted)
  Top 0.406: 130.18,15.88 VR36.1 | v134.62,36.2 LED7.A
  Top 0.61: Q31.E 129.22,35.88 v129.54,36.2 | 126.36,11.43 127.64,10.16 MINUS8-.1
  Top 0.813: 126.36,11.43 D13.C | D35.C 130.18,15.88 130.18,11.43 MINUS8-.1
  Bottom 0.406: v129.54,36.2 v134.62,36.2
  Bottom 0.61: 128.91,36.2 v129.54,36.2 | 126.36,12.7 127.25,15.49 128.14,15.49
  Bottom 1.27: MINUS8-.1 PLUS7+.1
  Bottom 1.422: 128.91,73.66 128.91,36.2 128.91,11.43 128.14,15.49 127.64,13.34 127.64,73.66
  Bottom 1.778: Q15.E Q21.E 125.48,40.01 125.73,40.01
  Bottom 2.54: 125.73,40.01 125.73,14.61 126.36,12.7 MINUS8-.1 132.87,13.49 R5.2
  pour Top (isolate 0.813): 120.02,46.99 123.83,46.99 125.73,44.45 125.09,38.73 120.65,38.73 120.02,44.45
E9  (via drill 0.6)  (1 unrouted)
  Top 0.406: 111.12,15.88 VR28.1 | v115.57,36.2 LED8X.A | Q2S.3 104.52,58.49 K2.P
  Top 0.61: Q30.E 110.17,35.88 v110.49,36.2 | MINUS9-.1 107.31,10.16
  Top 0.813: D14.C 111.12,15.88 111.12,11.43 MINUS9-.1
  Top 1.27: Q29.E Q2T.E
  Bottom 0.406: v110.49,36.2 v115.57,36.2 | 109.86,73.66 108.58,73.66
  Bottom 0.61: 109.86,36.2 v110.49,36.2 | 109.86,13.97 PLUS8+.1
  Bottom 1.27: 102.62,46.99 Q29.E 106.05,46.23 106.05,43.69
  Bottom 1.422: 109.86,13.97 109.86,36.2 109.86,73.66 | 108.58,73.66 108.58,57.15 108.58,11.43
  Bottom 1.778: 109.86,9.53 109.86,13.97
  Bottom 2.54: 106.05,43.69 106.68,40.01 106.68,11.43 MINUS9-.1 | R4.2 113.82,13.49 MINUS9-.1 | MINUS9-.1 109.86,9.53 | K2.P 109.17,56.84 109.22,56.9 108.84,56.9 108.58,57.15
E10  (via drill 0.5)  (5 unrouted)
  Top 0.406: K2.1 99.19,76.83 102.11,79.76 102.11,80.44 D9A.C | VR18.2 88.9,10.92 MINUS10.1 | VR23.2 88.71,32.07 v88.65,31.5 D10A1.A | Q5.2 89.22,52.64 JP14.2
  Top 0.813: MINUS10.1 92.08,11.43 92.08,15.88 D9.C
  Top 1.676: K1.P 84.32,73.22 Q10S.3
  Bottom 0.406: K2.1 91.06,76.83 89.66,75.44 | 89.41,17.02 89.41,9.65 MINUS10.1 | v88.65,31.5 89.15,32.26 89.15,32.51 | 89.15,52.07 JP14.2
  Bottom 0.61: SP3.- 89.15,29.46 89.41,29.21
  Bottom 1.676: PLUS9+.1 90.17,16.26 89.41,17.02 89.41,29.21 89.15,32.51 89.15,52.07 89.41,59.44 | 89.41,59.44 89.41,59.69 88.65,60.45 Q1.E Q1T.E | K1.P 88.32,70.69 88.9,70.1 88.9,59.94 89.41,59.44
GATE
  Top 0.406: FQFET.1 269.5,43.4 FRGS.2 270.99,41.43 271.78,40.64 271.78,37.47 271.14,36.83 271.14,35.71 FRGTE.1 270.51,35.56 269.88,34.92 FQ1.C
GP3  (via drill 0.5)  (1 unrouted)
  Top 0.406: v74.99,50.48 74.99,49.13 Q6.2 | v83.06,59.18 83.06,60.45 86.87,60.45 87.57,62.23 87.5,62.17 v87.44,86.04
  Bottom 0.406: SP3.+ 77.72,29.67 77.72,33.53 74.93,36.32 74.93,40.39 77.47,42.93 77.47,45.21 74.93,45.72 74.93,49.28 v74.99,50.48 75.44,51.05 75.95,51.88 77.72,54.36 77.72,57.66 v83.06,59.18 | v87.44,86.04 87.63,89.41 91.69,89.92 107.44,89.15
HOT  (via drill 0.6)
  Top 0.813: PQ2.C PQ1.2 93.98,102.36 94.61,103 96.52,103 98.42,104.9 v98.42,105.54 P_L1.1 100.67,105.58 PDHOT.C
  pour Top (isolate 0.813, hatched): 96.52,108.08 100.33,108.08 101.6,106.81 101.6,100.46 100.97,99.82 95.25,99.82 93.34,101.73 92.08,101.73 92.08,103 93.98,103 95.89,104.9 95.89,105.54 96.52,106.17
  pour Bottom (isolate 0.813, hatched): 96.52,104.27 100.33,104.27 101.6,103 101.6,92.08 100.97,91.44 98.81,92.2 93.34,97.92 92.08,97.92 92.08,99.19 93.98,99.19 95.89,101.09 95.89,101.73 96.52,102.36
IN+1
  Top 0.406: 26.37,89.84 V-TO3.1 32.38,88.9 VMABDT.3 | TO92S.3 27.3,69.85 27.3,71.12 V-SO8.1
  Top 0.813: 27.3,66.67 27.3,71.12
  pour Bottom (isolate 0.813, hatched): 44.45,71.75 44.45,66.67 37.34,66.55 38.61,71.63
  pour Top (isolate 0.813, rank 3, hatched): 26.8,98.3 27.3,95.89 32.07,93.34 33.97,86.36 22.86,86.36 19.68,84.45 19.68,79.38 27.3,79.38 30.8,74.36 31.62,73.53 arc139 41.91,71.75 44.45,71.75 44.45,66.67 28.57,66.67 27.3,66.04 27.3,71.75 arc90 23.5,75.56 19.37,75.88 16.51,77.79 16.51,87.63 18.41,89.53 21.78,89.66 21.97,96.9 24.26,98.3
  pour Bottom (isolate 0.813, rank 4): 30.48,87 17.14,87 17.21,88.2 19.94,90.04 20.19,90.04 21.08,90.93 21.34,99.31 14.22,106.43 10.92,106.43 4.83,106.55 4.45,112.65 11.43,112.39 14.48,107.06 22.61,99.31 23.88,96.52 23.88,98.55 24.13,98.81 25.15,93.98 29.21,93.47 29.21,93.34 33.02,93.34 33.02,88.27
IN-  (via drill 1.3)
  Top 0.406: VCQ.E 40.63,96.96 | VR-B.2 41.3,99.74 VD2.A
  Top 0.813: 40.63,96.96 VD2.A
  Top 2.54: v205.1,122.56 v41.91,122.56
  Bottom 0.406: 46.99,100.33 VRSHNT.2 44.45,103.5 VIN(-).1
  Bottom 2.54: MINUS120.1 219.15,104.7 v205.1,122.56 | v41.91,122.56 VIN(-).1
  pour Bottom (isolate 0.813, rank 2): 36.83,108.58 47.62,108.58 48.9,106.05 48.9,98.42 36.83,98.42
  pour Top (isolate 0.813, rank 2, hatched): 49.15,109.22 48.9,98.42 39.37,98.42 38.61,98.68 38.61,112.27
INPUT+  (via drill 1)
  Top 0.406: C-SO8.1 33.97,48.58 v31.81,49.53 V-TO1.1 | CCIO1.1 CDZIO.C | 34.29,43.18 C-TO92.3 | C-SO8.1 34.29,46.35 | 34.29,45.72 C-SO8.1 | v31.75,57.4 CMABDT.3
  Top 0.61: 38.73,59.05 CO1.1
  Top 0.813: 34.29,45.72 34.29,43.18 34.29,41.27 | CQHV.E 38.73,59.05
  Bottom 1.27: C-1083.3 C-TS.3
  pour Top (isolate 0.61, rank 2, hatched): 34.92,60.33 27.94,60.33 27.3,52.07 22.86,52.07 22.86,48.26 24.13,48.26 24.77,47.62 33.02,47.62 33.02,46.99 34.92,46.99
  pour Bottom (isolate 0.813, rank 2, hatched): 44.45,58.42 34.29,60.33 29.21,60.33 29.21,53.98 22.23,48.9 22.23,46.35 24.13,44.45 24.13,41.91 22.23,38.73 22.23,27.94 31.11,27.94 38.73,24.13 42.55,24.13 42.55,31.11 32.38,31.11 26.67,34.92 26.67,45.09 27.94,46.35 34.92,48.9 34.92,55.88 44.45,56.52
  pour Top (isolate 0.813, rank 2): 39.37,27.94 43.81,27.94 43.81,15.88 39.37,15.88
MINUS
  Top 0.406: CTRIM3.A 17.65,20.32 10.16,20.32 9.7,20.79 9.72,27.75 9.72,30.67 10.16,31.11 CDT3L2.C 10.59,32.59 10.79,32.38 10.64,32.38 CD4.2
  Bottom 0.406: TRIM3X.E CTRIM3.A
N$1
  Bottom 0.406: 17.7,67.63 VPOT2.A | VPOT1.E 17.78,65.98
  Bottom 1.016: VPOT1.E 17.7,67.63
  Bottom 1.27: 17.78,65.98 VO2.2
N$2
  Top 0.406: VRT2.2 17.7,73.66 VPOT1.A 15.43,74.8 arc-135 14.61,79.38 VRT3.2
  Bottom 0.813: 17.72,74.02 VPOT1.A
  Bottom 1.27: VPOT2.E 17.72,74.02
N$3
  Top 0.406: VTRIM1.E VRB1.2
  Bottom 0.813: VTRIM1.E 30.16,84.45
  pour Bottom (isolate 0.813, rank 2, hatched): 33.66,85.72 33.66,83.82 34.61,82.55 28.57,82.55 27.94,83.19 27.94,85.72
N$4
  Bottom 0.406: VRT1.1 30.12,77.15 30.12,78.78 | VTRIM1.A 27.73,79.42 VO1.2
  Bottom 0.813: VTRIM1.A 30.12,78.78
  pour Bottom (isolate 0.813, rank 3, hatched): 33.66,81.28 32.38,76.83 30.48,74.93 27.94,75.56 27.94,80.64 28.57,81.28
N$5
  Bottom 0.406: 19,26.04 CTRIM3.E TRIM3X.A
  Bottom 0.61: 22.27,25.36 20.95,26.04 19,26.04
  Bottom 0.813: CTRIM2.A 25.4,20.36 CTRIM2.S 22.86,24.77 22.27,25.36
N$6
  Top 0.813: CRT2H.1 25.47,27.79 CTRIM2.E
N$7
  Top 0.406: VR3X.1 VR3.1
  Bottom 0.406: VR3.1 VCLO.1 VCHI.2
  pour Bottom (isolate 0.813, rank 3): 35.56,98.42 28.57,98.42 33.91,112.14 38.1,112.14
  pour Top (isolate 0.813, rank 4): 37.59,98.42 28.57,98.42 33.4,111.25 37.85,111.51
N$8
  Top 1.27: B3.~1 253.4,71.15 254,71.75 254,73.34 B1.AC1
  Bottom 1.27: B1.AC1 254.32,75.88 JP1.1
N$9
  Bottom 0.813: CCOUT.- 33.02,19.05 VIN(-)1.1
  pour Bottom (isolate 0.813): 29.84,22.23 38.73,22.23 38.73,17.14 34.92,17.14 33.66,15.88 30.48,15.88 29.84,16.51
  pour Top (isolate 0.813): 29.84,22.23 38.73,22.23 38.73,15.88 30.48,15.88 29.84,16.51
N$10
  Top 1.016: VZDHV.C 18.4,105.27 19.81,106.68 19.81,108.46 20.32,108.97 20.32,109.22 22.35,111.25 23.62,111.25 | 23.62,111.25 VQHV.B | 23.62,111.25 23.62,109.07 VRHV.1
N$11
  Top 0.406: VR14.1 75.18,52.83 77.6,51.24 77.6,48.86 LED10X.C
N$12
  Top 0.406: VR3.2 VR3X.2
  Top 0.813: VD-S2.C 31.15,95.45 VR3X.2 | VR8X.1 VRB1.1 | VO2.1 VRB2.1
  Bottom 0.813: 34.92,84.09 arc-77 23.56,70.67 23.05,70.67 21.4,68.83 VO2.1
  Bottom 1.27: VR3.2 31.69,93.41 34.92,92.08 VR8X.1 34.92,84.09
N$13
  Top 0.813: VD-S1.C 33.02,100.97 VD-S2.A
N$14
  Top 0.406: D10A.A 73.15,23.23 VR48.2 74.17,24.3 74.17,23.88 74.68,23.37 75.18,23.37 75.82,22.73 77.85,22.73 TRIM10X.A
N$15  (via drill 0.5, 0.7)
  Top 0.406: IC2.4 82.23,47.69 v81.41,47.56 | VR11.1 81.51,58.04 81.6,58.04 84.98,58.06 | v84.52,54.61 Q14.C 84.98,58.06 | 88.65,62.42 87.38,59.18 D10A2.C 84.98,58.06
  Top 0.61: 88.65,62.42 88.65,87.38 87.12,88.14 82.93,89.15 K1.1
  Bottom 0.406: v81.41,47.56 80.9,47.82 80.52,49.02 80.52,54.61 v84.52,54.61
N$16
  Top 0.406: VR28.2 123.19,15.88 124.46,17.14 124.46,22.86 125.09,23.5 125.09,26.98 OK8X.1
N$17
  Top 0.406: VR2.2 73.43,19.79 D10A.C 72.64,19 72.9,19.05 72.98,18.97 D10.A 78.11,14.85 TRIM10X1.A
N$18
  Top 0.406: FQHVU.3 273.05,32.38 273.69,33.02 273.69,35.41 FRGTE.2
N$19
  Top 0.406: FRHVT.1 273.84,17.93 273.05,17.14 269.24,17.14 268.61,17.78 FDZHV.A
N$20
  Top 0.406: D9.A 95.58,21.26 95.76,21.08 | 95.76,21.08 TRIM9X.A 97.03,19.81 97.03,21.08 97.66,22.48 VR51.1 | VR5.1 95.82,21.14 95.76,21.08
N$21
  Top 0.406: FRHVT.2 FRHVL.1 270.99,24.61 271.78,25.4 271.78,25.89 FQHVU.1
N$22  (via drill 0.5)
  Top 0.406: TRIM10X1.S 80.64,14.86 75.95,19.56 75.95,21.84 74.7,21.84 VR2.1 | VR79.2 78.49,35.9 v78.49,34.8 77.47,35.81 VR78.2
  Bottom 0.406: v78.49,34.8 78.49,30.99 78.99,30.48 78.99,27.18 77.72,25.91 77.72,24.89 75.44,22.61 75.44,18.8 79.5,16 79.5,15.62 TRIM10X1.S
N$23
  Top 0.406: Q13.B 74.65,58.35 VR13.1
N$24
  Top 0.406: TRIM10X1.E 83.19,15.37 84.33,16.26 84.99,15.6 VR19.1
N$25  (via drill 0.5)
  Top 0.305: Q10S.1 79.25,76.35 79.25,67.06 77.72,65.53 Q1T.B
  Top 0.406: VR49.1 80.01,55.97 80.01,57.91 VR11.2 79.5,58.93 v77.98,58.93
  Bottom 0.406: v77.98,58.93 Q1T.B Q1.B
N$26
  Top 0.406: D15.A 114.09,24.02 VR54.1
  Top 0.813: VR54.1 114.62,21.27 TRIM8X.A
N$27
  Top 0.406: 122.56,23.18 VR53.1 122.87,25.19 D12.A
  Top 0.813: TRIM8X.E 122.56,20.95 122.56,23.18
N$29
  Top 0.813: D15.C 110.69,23.09 D14.A
N$31
  Top 0.406: LED8X.C 119.53,33.81 120.02,34.29 121.13,34.29 VR29.1 121.77,33.66 121.92,33.66 124.46,31.11 125.73,31.11 126.36,30.48 OK8X.2
N$32  (2 unrouted)
  Top 0.406: 127,25.51 D12.C
  Top 0.813: D13.A 126.36,22.86 127,23.5 127,25.51
N$33
  Top 0.406: Q15.B 114.3,41.91 113.67,41.27 113.67,30.33 VR12.2 114.45,29.21 114.94,29.21 118.43,25.72 VR55.2
  Top 0.61: Q3.1 115.83,44.71 115.57,44.45 Q15.B
  Top 1.27: Q15.B Q21.B
  Bottom 1.27: Q15.B 113.03,41.91
N$34  (via drill 0.6)
  Top 0.406: DLED.2 133.32,101.58
  Top 0.61: DCBLK1.+ 147.96,94.61 148.59,94.61 | 148.59,94.61 IC1.1 U$2.5 | v132.72,105.41 132.08,105.72 | DCBLK2.1 148.72,94.74 148.59,94.61
  Top 0.813: 132.08,105.72 DQ1.3 | 133.32,101.58 133.35,104.14 v132.72,105.41
  Bottom 0.813: DCBLK1.+ 140.97,96.52 v132.72,105.41
N$35  (via drill 0.6)
  Top 0.406: DRRED.2 135.41,86.21 135.89,85.53 168.28,85.53
  Top 0.61: U$2.1 154.69,99.44 155.57,100.33 IC1.7 | 168.28,85.53 168.28,85.66 170.18,87.57 170.5,89.53 170.5,96.58
  Top 0.813: 170.5,96.58 170.5,104.78 v163.19,104.78
  Bottom 0.406: v163.19,104.78 156.21,104.78 155.57,104.14 IC1.7
N$36
  Top 0.406: IC1.6 158.12,104.14 157.48,104.78 150.5,104.78 | 141.12,104.78 DRBLU.2 | U$2.3 151.38,99.44 150.5,100.33
  Top 0.813: 141.12,104.78 150.5,104.78 150.5,100.33
N$37  (via drill 0.6)
  Top 0.406: 147.07,97.41 U$2.4 | v142.88,87 141.76,87 DRGRN.2
  Top 0.61: 147.07,97.41 146.05,99.06 142.88,99.06 140.97,97.16 140.97,88.11 DRGRN.2
  Top 0.813: DDMEAS.C 167.21,87.83 v168.28,88.9
  Bottom 0.406: IC1.5 164.47,102.23 165.74,103.5 170.18,103.5 170.5,102.87 170.5,88.9 170.18,87.63 | 170.18,87.63 168.28,85.72 143.51,85.72 v142.88,87 | v168.28,88.9 168.91,88.9 170.18,87.63
N$38
  Top 0.813: PQ1.3 86.13,100.05 85.09,101.09 85.09,101.24 PQ2.E 78.55,101.41 PRE.2
N$39
  Top 0.61: 73.66,112.52 74.93,114.43 87.63,114.43 88.27,113.16
  Top 0.813: 92.11,107.44 92.71,107.44 | 92.11,107.44 L2.2 92.03,107.44 | PSOK2.3 73.66,112.52 | PQ2.B 85.26,104.44 85.72,104.9 88.9,104.9 | 88.9,104.9 90.65,104.9 PQ1.1 | 88.27,113.16 88.27,108.08 88.9,107.44 | 88.9,107.44 92.03,107.44 | 92.03,107.44 92.11,107.44 | 88.9,107.44 88.9,104.9
N$40
  Top 1.27: B1.AC2 250.51,71.44 250.82,71.12 250.82,69.75 B3.~2
  Bottom 1.422: JP2.1 250.19,73.98 B1.AC2
N$41
  Top 0.813: PSOK2.2 81.76,112.52 PSR23.2 85.45,112.67 PZDFB.C
N$42
  Top 0.813: PSR22.2 80.16,107.29 80.01,107.44 80.01,108.08 79.38,108.71 79.38,109.67 PSOK2.1
N$43
  Top 0.813: L2.1 90.17,115.7 72.24,115.7 PS16.1 | PS16.1 69.37,112.52 | PS16.1 69.06,112.52 67.31,112.52 65.41,110.62 65.41,101.73 68.58,101.73 69.97,103.12 PCT1.1 PCB.2
N$45
  Top 0.406: Q35.C 206.22,31.77 VR39.1
N$46
  Top 0.61: DDZ1.C 126.16,103.35 DRTOP.2 126.69,103.63 DQ1.1
N$47
  Top 0.813: DRRED.1 132.56,90.77 DLED.1
N$48
  Top 0.61: 137.64,98.65 DLED.3
  Top 0.813: 137.64,98.65 DRBLU.1
N$49
  Top 0.813: DRGRN.1 138.28,91.71 DLED.4
N$50
  Top 0.406: Q16.B 151.76,41.91 151.76,30.48 152.4,30.33 VR25.2 152.55,29.21 153.03,29.21 156.53,25.72 VR61.2
  Top 0.61: Q9.1 153.93,44.71 153.67,44.45 Q16.B
  Top 1.27: Q16.B Q39.B
  Bottom 1.27: Q16.B 151.13,41.91
N$51
  Top 0.406: Q17.B 190.5,41.91 189.87,41.27 189.87,31.11 VR26.2 190.65,29.21 191.13,29.21 194.63,25.72 VR67.2
  Top 0.61: Q8.1 192.03,44.71 191.77,44.45 Q17.B
  Top 1.27: Q17.B Q41.B
  Bottom 1.27: Q17.B 189.23,41.91
N$52
  Top 0.406: 227.97,41.91 227.97,31.75 228.12,31.6 VR27.1 228.75,29.21 229.24,29.21 232.73,25.72 VR73.2
  Top 0.61: Q7.1 230.13,44.71 229.87,44.45 Q18.B
  Top 1.27: Q18.B 227.97,41.91 Q43.B
  Bottom 1.27: Q18.B 227.33,41.91
N$53
  Top 0.813: VENTILATOR.2 112.39,104.9 P_Q2.2 VQ1.3
N$54
  Top 0.406: CDT3L1.C 7.62,33.02 8.26,33.02 9.53,35.35 CDT3L2.A
N$55
  Top 0.813: D34.C 145.84,22.23 D33.A
N$56  (via drill 0.6)
  Top 0.406: v100.33,27.94 U$7.2 | D9A1.A 93.73,32.26 v93.47,33.78 92.2,33.78 91.44,34.54 OK9X.3 92.4,37.34 101.35,37.34 101.41,37.15 C1.2 102.55,35.56 104.14,35.56 104.9,36.07 104.9,39.37 105.22,40.07 Q2.2 | D18.A 106.05,15.62 100.58,10.16 100.58,8.51 M-9BAT.1
  Bottom 0.406: v93.47,33.78 93.47,18.29 95.25,16.51 100.58,16.51 104.14,14.99 | 104.14,14.99 104.14,11.05 M-9BAT.1 | 104.14,14.99 102.62,16 103.63,17.27 103.63,17.78 104.14,18.03 104.14,22.61 102.62,24.13 102.11,25.91 100.33,25.91 v100.33,27.94 | K2.O 95.12,60.33 91.95,60.2 91.19,59.69
  pour Bottom (isolate 0.305): 97.03,9.14 98.04,7.37 102.11,7.37 104.9,10.41 104.9,15.75 100.58,17.78 97.28,18.03 95.5,18.54 95.5,43.94 92.71,45.72 92.71,48.51 93.73,49.53 97.79,49.53 97.79,50.29 98.81,52.32 98.81,59.69 96.27,62.74 91.44,62.74 90.68,61.21 90.68,55.37 95.25,55.37 96.52,54.1 96.52,52.58 95.5,51.56 91.44,51.56 91.19,51.31 91.19,13.97 95.76,9.4
N$57
  Top 0.406: VR56.1 142.44,24.02 D33.C
  Top 0.813: TRIM7X.E 141.92,21.27 VR56.1
N$58
  Top 1.27: B4.~1 234.34,70.45 235.27,71.37 B2.AC1
  Bottom 1.27: JP3.1 236.16,76.83 235.2,75.88 235.2,73.72 B2.AC1
N$59
  Top 1.27: B4.~2 231.75,71.53 231.46,71.82 B2.AC2
  Bottom 1.27: JP4.1 231.14,76.52 231.46,76.2 B2.AC2
N$60
  Top 1.27: B6.~1 215.29,70.52 215.9,71.12 215.9,71.18 216.22,71.5 B5.AC1
  Bottom 1.27: JP5.1 217.17,76.71 216.22,75.75 B5.AC1
N$61
  Top 1.27: B6.~2 212.69,71.72 212.41,72.01 B5.AC2
  Bottom 1.27: JP6.1 212.09,76.45 212.41,76.14 B5.AC2
N$62
  Top 0.406: 190.82,22.67 VR66.1 190.29,24.02 D27.A
  Top 0.813: TRIM3-9.A 190.82,21.02 190.82,22.67
N$63
  Top 0.406: VR65.1 199.59,24.02 D22.C
  Top 0.813: TRIM3-9.E 199.07,21.27 VR65.1
N$64
  Top 0.406: Q34.B 188.59,33.47 188.59,33.02 188.59,27.56 191.26,27.56 191.77,27.05 191.77,25.4 192.41,24.77 192.41,24.01 VR66.2 | VR65.2 VR67.1
  Top 0.813: TRIM3-9.S 194.94,22.86 | 194.94,22.86 194.31,23.5 VR66.2 | VR65.2 195.58,23.5 194.94,22.86
N$65
  Top 0.406: 135.89,23.5 VR57.2 135.25,23.82 135.25,24.83 134.62,25.46 134.62,27.05 134.11,27.56 131.44,27.56 131.44,33.8 Q31.B | VR56.2 140.34,23.81 140.34,24.77 140.01,25.08 VR58.1
  Top 0.813: 137.03,23.5 137.79,22.86 TRIM7X.S | 137.03,23.5 135.89,23.5 | VR56.2 138.43,23.5 137.86,22.92 137.03,23.5
N$66
  Top 0.406: VR60.1 152.19,24.02 D25.A
  Top 0.813: TRIM5X.A 152.72,21.27 VR60.1
N$67
  Top 0.406: Q31.C 130.18,30.63 VR20.1
N$68
  Top 0.813: D19.C 164.9,21.82 D20.A
N$69
  Top 0.406: 146.25,87 DDZ2.A 146.08,87.22
  Top 0.813: 146.08,87.22 DTRIM.E
N$70
  Top 0.813: D21.C 203,22.45 D22.A
N$71
  Top 0.813: D26.A 148.79,23.09 D25.C
N$72
  Top 0.406: VR59.1 161.5,24.02 D20.C
  Top 0.813: TRIM5X.E 160.97,21.27 VR59.1
N$73
  Top 0.813: D28.A 186.9,23.5 D27.C
N$74
  Top 0.813: D29.C 225.25,24.31 225.43,23.5 D30.A
N$75
  Top 0.406: U$2.6 157.86,97.41 158.12,97.16 IC1.3 | 163.47,91.23 DRTRM.2
  Top 0.813: DDMEAS.A 163.47,91.23 | DRTRM.2 161.31,91.59 DCMEAS.1 IC1.3
N$76
  Top 0.406: CHARGE.1 92.2,86.87 90.68,85.85 90.68,84.05 VR21.1
N$77
  Top 0.406: OK6X.2 164.47,29.21 163.35,30.33 VR30.1 159.06,33.81 LED4.C
N$78
  Top 0.406: OK4X.2 202.56,29.84 202.08,30.33 VR31.1 197.16,33.81 LED5.C
N$79
  Top 0.406: LED6.C 235.59,33.81 VR32.1 236.22,34.14 236.22,33.02 238.12,31.11 240.03,31.11 240.66,30.48 OK2X.2
N$80
  Top 0.406: OK6X.1 161.93,27.94 163.19,26.67 163.19,23.5 162.56,22.86 162.56,17.14 161.29,15.88 VR35.2
N$81
  Top 0.406: VR33.2 199.39,15.88 200.66,17.14 200.66,22.86 201.29,23.5 201.29,26.67 200.03,27.94 OK4X.1
N$82
  Top 0.406: VR34.2 237.49,15.88 238.76,17.14 238.76,22.86 239.4,23.5 239.4,26.67 238.12,27.94 OK2X.1
N$83
  Top 0.813: DDZ3.A 144.24,90.82 DDZ2.C
N$84
  Top 0.813: CQHV.B CRHV.1 37.67,52.55 CDZHV.C
N$85
  Top 1.27: B8.~1 196.25,70.39 197.17,71.31 B7.AC1
  Bottom 1.27: JP7.1 197.93,76.83 197.17,76.07 B7.AC1
N$86
  Top 0.406: TRIM9X.S 99.69,20.95 100.84,22.1 100.84,23.05 VR50.2 99.83,23.88 99.57,23.88 98.05,25.4 VR51.2 97.66,25.4 97.03,25.4 96.52,24.89 93.98,24.89 93.03,25.47 Q19.B
N$87  (via drill 0.6)
  Top 0.406: Q2S.1 99.95,60.33 v99.06,61.98
  Top 1.27: 94.49,46.99 Q2T.B 96.46,46.16 VR15.2
  Bottom 0.406: v99.06,61.98 99.31,60.71 99.31,51.82 96.77,49.02 96.77,47.24 Q2T.B
  Bottom 1.27: Q2T.B Q29.B
N$88
  Top 0.406: D36.A 133.15,24.02 VR57.1
  Top 0.813: VR57.1 133.67,21.27 TRIM7X.A
N$89
  Top 0.813: D37.C 183.94,22.45 D38.A
N$90
  Top 1.27: B8.~2 193.65,71.09 193.36,71.37 B7.AC2
  Bottom 1.27: JP8.1 193.04,75.69 193.36,75.37 B7.AC2
N$91
  Top 0.406: 129.54,25.83 D36.C
  Top 0.813: D35.A 130.81,22.23 129.54,23.5 129.54,25.83
N$92
  Top 0.406: Q34.C 187.17,31.44 VR26.1
N$93
  Top 0.406: Q22.B 133.35,41.91 132.72,41.27 132.72,29.69 VR20.2 133.35,29.84 137.48,25.72 VR58.2
  Top 0.61: Q20.1 134.88,45.34 134.62,45.09 Q22.B
  Top 1.27: Q22.B 131.44,41.91
  Bottom 1.27: Q22.B Q38.B
N$94
  Top 0.406: LED9X.C 100.56,39.97 VR24.1
N$95
  Top 0.406: OK9X.1 93.98,42.93 91.19,45.47 91.19,77.47 VR21.2
N$96
  Bottom 0.406: SP1.+ 167.64,95.25 165.74,97.16 156.21,97.16 155.57,96.52 IC1.2
N$97
  Top 1.27: B10.~1 177.19,70.52 178.12,71.44 B9.AC1
  Bottom 1.27: JP9.1 178.12,75.88 B9.AC1
N$98