# EAGLE board 21032012V10e (EAGLE 5.07), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via)
ADJ2  (via drill 1)
  Top 0.406: 22.23,62.23 V-SO8.4 21.78,63.65 | VMABDT.1 33.28,84.75 | V-TO3.2 19.68,74.3
  Top 0.813: 22.23,62.23 TO92S.1 | 21.78,63.65 VRB2.2 19.2,63.65 18.41,62.87 16.75,62.87 VPOT1.S | 33.28,84.75 VCAD.+
  Top 1.27: v22.37,76.39 V-TO3.2
  Bottom 0.406: 39.91,72.3 V-1083.1 V-TS.1 | 39.91,72.3 39.37,72.83 | 39.91,72.3 40.64,73.03 v40.64,74.61 41.27,74.93 | V-TO3.2 20.01,74.33 VTRIM1.S 23.85,74.3 VO1.1
  Bottom 0.813: VPOT1.S VPOT2.S 17.46,62.55 18.35,63.44
  Bottom 1.27: 18.35,63.44 arc30 22.23,73.66 v22.37,76.39
  pour Bottom (isolate 0.813, hatched): 39.37,76.83 43.18,76.83 43.18,69.22 41.91,67.94 39.37,67.94
  pour Top (isolate 0.813, hatched): 43.18,77.47 43.18,69.22 42.55,68.58 40.01,68.58 39.37,69.22 arc77 32.38,71.75 23.5,74.3 34.29,76.2 34.29,81.92 33.02,83.19 33.34,88.27 36.83,86.36 36.83,78.74 38.73,77.47
ADJUST  (via drill 0.6, 1)
  Top 0.406: 27.53,37.21 CRLM3.1 | V-TO1.2 19.22,34.29 v17.72,32.07 18.41,31.11 | 29.21,36.83 C-SO8.4 | 29.21,35.56 29.21,36.83 | 9.62,31.68 8.98,31.68 C.A | C.A C..A A.A 6.35,31.11 CDT3L1.A | 29.21,36.83 28.57,36.83 | 29.21,35.56 29.21,33.66 | C-TO92.1 29.21,35.56 | CD4.1 11.79,26.37 10.79,27.3 10.79,29.84 9.53,31.11 9.53,31.14 C.A
  Top 0.813: C-1083.1 35.63,34.87 CDZHV.A | CMABDT.1 31.49,47.25 33.66,45.09 33.66,42.55 CDZHV.A | CDZHV.A 36.65,41.27 38.73,41.27 38.99,41.02 CQREG.E
  Top 1.016: 27.53,37.21 28.57,37.21 28.57,36.83
  Top 1.27: v29.21,28.26 28.32,28.45 arc-33 18.41,31.11
  Bottom 0.406: C-1083.1 39.5,32.38 | 29.72,33.85 C-TO92.1
  Bottom 0.813: 29.72,30.54 29.72,33.85
  Bottom 1.27: C-TS.1 C-1083.1 39.37,31.75 37.47,31.75 arc37 29.91,29.34 29.72,29.15 | v29.21,28.26 29.21,28.64 29.72,29.15 | 29.72,29.15 29.72,30.54
  pour Bottom (isolate 0.813, hatched): 19.68,32.38 arc-90 17.78,30.48 4.45,30.48 3.81,31.75 3.81,33.66 5.08,34.92 10.79,34.92 11.43,35.56 19.68,35.56
  pour Top (isolate 0.61): 29.84,39.37 20.95,39.37 20.95,36.83 28.57,36.2 29.21,35.56 29.84,35.56
B
  Top 0.406: VR48.1 78.72,15.9 | VR48.1 78.75,14.59 79.38,13.97 TRIM10X.S | VR48.1 VR47.2 VR49.2 | Q14.B 73.97,25.72 74.3,25.4 74.3,20.95 74.93,20.32 75.56,20.32 76.2,19.68 76.2,18.41 77.47,17.14 77.47,16.2 VR48.1
B1
  Bottom 0.406: 42.55,8.89 44.07,9.97 44.07,35.37 42.55,36.2 42.16,36.2 CQREG.B
  Bottom 0.61: 42.55,8.89 33.66,8.89 32.38,7.62 27.94,7.62 26.67,8.89 13.97,8.89 11.43,11.43 CTRIM3.S TRIM3X.S
B-Q1
  Top 0.406: FCB.2 267.33,22.71 FQ1.B 266.06,24.62 266.06,26.67 266.7,27.3 FRBOUT.2
BATT-  (via drill 0.6)  (2 unrouted)
  Top 0.406: PS16.2 67,92.88 66.84,92.88 66.04,92.08 66.04,90.94 PCT1.2 65.91,88.39 v66.04,88.27 | v84.45,91.44 PZDFB.A | VTQ1.2 v114.3,79.5 114.3,80.64 113.44,81.51 P_Q2.3 | P_C6.A 105.12,89.34 P_C10.- | v273.37,23.5 273.69,22.86 273.69,19.68 272.73,18.73 FQHVU.2 272.73,15.4 FRHVL.2 | VENT_RB.2 103.35,79.86 v102.23,78.74 VZD1.A | SDL1.A 258.44,6.99 MINUS1-.1 | DTRIM.A 152.88,84.61 153.03,84.45 154.94,84.45 155.57,83.82 155.57,82.55 156.72,81.92 DC2.2
  Top 0.61: IC1.8 U$2.2 | DZD1.A 121.49,80.85 120.02,79.38 114.43,79.38 v114.3,79.5
  Top 1.27: 252.25,54.61 B3.-
  Top 1.422: B1.- 256.86,63.82 255.27,62.23 255.27,56.52 253.37,54.61 252.25,54.61
  Bottom 0.406: v66.04,88.27 66.04,81.28 67.31,80.64 84.45,80.64 v84.45,91.44 | 114.3,80.64 118.75,80.64 118.75,79.38 121.28,76.83 263.52,76.83 | 114.3,80.64 106.05,80.64 | 106.05,80.64 102.23,80.64 v102.23,78.74 | 114.3,80.64 v114.3,79.5 | P_C10.- 106.05,89.53 106.05,80.64 | 149.22,94.61 IC1.8 151.76,92.71 152.4,92.08 163.83,92.08 165.53,93.78 SP1.- | 149.22,94.61 149.22,88.27 147.61,86.65 DTRIM.A | 149.22,94.61 146.05,94.61 DC9.- 144.15,93.98 142.88,92.71 | 263.52,23.5 v273.37,23.5
  Bottom 0.813: 102.23,80.64 84.45,80.64 | B1.- 258.9,67.48 258.44,66.67 | 257.68,37.34 258.44,39.37
  Bottom 1.27: (BATT-).1 MINUS1-.1
  Bottom 1.422: 258.44,39.37 258.44,66.67
  Bottom 1.778: Q28.E Q44.E
  Bottom 2.54: S1.5 197.49,97.79 211.46,83.82 255.27,83.82 | MINUS60.1 256.62,95.33 255.27,93.34 255.27,83.82 | 255.27,83.82 263.52,76.83 263.52,23.5 263.52,9.53 260.35,6.35 MINUS1-.1 257.81,7.62 257.81,31.5
  pour Top (isolate 0.813): 252.09,39.37 255.91,39.37 257.81,36.83 257.81,32.38 252.73,32.38 252.09,36.83
  pour Bottom (isolate 0.813, rank 2, hatched): 64.77,97.16 64.77,80.64 66.67,78.74 168.91,78.74 170.18,80.01 170.18,98.42 168.91,99.69 67.31,99.69 65.41,97.79
CVIN
  Top 0.813: CRHV.2 41.12,47.78 CQHV.C | CRHV.2 36.35,47.78 | CO1.2 36.2,47.78 CRHV.2
  Bottom 1.778: C_VIN+.1 CQHV.C
D
  Top 1.27: F2.1B 270.76,50.55 FRFS.2 | FQFET.3 FRFS.2 | FRFS.2 268.22,50.8 F2.1A
E2  (via drill 0.6)  (1 unrouted)
  Top 0.406: 243.21,8.26 243.21,6.99 MINUS2-.1 241.3,5.71 239.4,7.62 D23.A | 243.21,8.26 SDZH1.C | SRHOKD.1 243.21,8.26 | SLED1.A 250.82,27.3 R24.2
  Top 0.61: SQ1.E 242.89,27.62 v242.82,28.26
  Top 1.27: 249.4,54.61 B3.+ | B4.- 233.2,54.61 234.31,54.61
  Top 1.422: B1.+ 245.43,63.82 246.38,62.87 246.38,56.52 248.28,54.61 249.4,54.61 | 234.31,54.61 236.22,56.52 236.22,62.23 237.81,63.82 B2.-
  Bottom 0.61: v242.82,28.26 242.57,27.3 244.79,25.08
  Bottom 0.813: B1.+ 242.94,66.09 241.87,64.77
  Bottom 1.27: PLUS1+.1 MINUS2-.1 240.66,5.71 240.66,64.77 239.4,66.04 B2.-
  Bottom 1.422: 241.87,6.03 241.87,64.77
  Bottom 1.778: Q18.E Q43.E
  Bottom 2.54: R24.2 247.01,27.3 244.79,25.08 243.84,24.13 243.84,8.26 241.87,6.03 241.3,5.71 | MINUS2-.1 241.3,5.71 | 238.76,32.38 238.76,7.62 239.4,6.99 240.03,6.99 241.3,5.71
  pour Top (isolate 0.813): 233.04,39.37 236.85,39.37 238.76,36.83 238.12,31.11 233.68,31.11 233.04,36.83
E3  (via drill 0.6)  (3 unrouted)
  Top 0.406: VR34.1 225.43,8.26 224.16,6.99 | D39.A 220.34,6.99 MINUS3-.1 224.16,6.99 | LED6.A 231.78,26.67 R18.2 | 224.16,6.99 D30.C
  Top 0.61: Q36.E 223.84,27.62 v223.84,28.13
  Top 1.27: B6.- 214.15,54.61 215.26,54.61
  Top 1.422: 215.26,54.61 217.17,56.52 217.17,62.23 218.82,63.88 218.76,63.94 B5.- | B4.+ 230.35,54.61 229.24,54.61 227.33,56.52 227.33,62.87 226.38,63.82 B2.+
  Bottom 0.61: 226.06,25.4 v223.84,28.13
  Bottom 1.27: PLUS2+.1 MINUS3-.1 | 222.25,8.26 222.88,9.53 222.88,64.77 224.79,66.04 B2.+
  Bottom 1.422: 222.25,6.35 222.25,7.62 221.62,8.26 221.62,64.14 219.71,66.04 B5.-
  Bottom 1.778: Q27.E Q42.E
  Bottom 2.54: R18.2 227.97,27.3 226.06,25.4 224.79,24.13 224.79,8.89 222.25,6.35 | 219.71,32.38 219.71,7.62 MINUS3-.1
  pour Top (isolate 0.813): 214,39.37 217.81,39.37 219.71,36.83 219.07,31.11 214.63,31.11 214,36.83
E4  (via drill 0.6)  (1 unrouted)
  Top 0.406: 205.74,8.26 VR44.1 | LED10.A 212.72,26.67 R21.2 | 205.74,8.26 D46.C | 205.74,8.26 205.74,7.62 MINUS4-.1 201.29,6.99 D21.A
  Top 0.61: Q35.E 204.79,27.62 v204.47,27.94
  Top 1.27: B8.- 195.1,54.61 196.22,54.61
  Top 1.422: 196.22,54.61 198.12,56.52 198.12,62.23 199.71,63.82 B7.- | B6.+ 211.3,54.61 210.19,54.61 208.28,56.52 208.28,62.87 207.33,63.82 B5.+
  Bottom 0.406: MINUS4-.1 203.2,5.71 203.84,6.35
  Bottom 0.61: v204.47,27.94 205.1,27.94 207.33,25.72
  Bottom 1.27: MINUS4-.1 PLUS3+.1
  Bottom 1.422: B5.+ 205.74,66.04 203.84,64.14 203.84,6.35 | 202.56,5.08 202.56,64.77 201.93,65.41 200.34,65.41 B7.-
  Bottom 1.778: Q17.E Q41.E
  Bottom 2.54: R21.2 208.91,27.3 207.33,25.72 205.74,24.13 205.74,7.62 MINUS4-.1 202.56,5.08 202.56,5.71 200.66,7.62 200.66,32.38
  pour Top (isolate 0.813): 194.94,39.37 198.75,39.37 200.66,36.83 200.03,31.11 195.58,31.11 194.94,36.83
E5  (via drill 0.6)  (4 unrouted)
  Top 0.406: LED5.A 193.04,25.25 R16.2 | VR33.1 186.69,8.26 186.37,7.94 | 186.37,7.94 184.15,5.71 MINUS5-.1 184.15,6.99 182.25,8.89 D37.A | D28.C 186.37,10.68 186.37,7.94
  Top 0.61: Q34.E 186.38,27.62 v186.25,28.32
  Top 1.422: 180.66,63.82 179.07,62.23 179.07,56.52 177.16,54.61 177.04,54.73 B10.- | B8.+ 192.25,54.61 191.13,54.61 189.23,56.52 189.23,62.87 188.28,63.82
  Bottom 0.61: 188.28,25.72 v186.25,28.32
  Bottom 1.27: PLUS4+.1 MINUS5-.1
  Bottom 1.422: B7.+ 187.32,66.04 184.78,63.5 184.78,8.89 183.51,8.89 183.51,64.14 181.61,66.04 B9.-
  Bottom 1.778: Q26.E Q40.E
  Bottom 2.54: R16.2 189.87,27.3 188.28,25.72 186.69,24.13 186.69,8.26 184.78,6.35 184.78,5.71 MINUS5-.1 181.61,7.62 181.61,32.38
  pour Top (isolate 0.813): 175.9,39.37 179.71,39.37 181.61,36.83 180.97,31.11 176.53,31.11 175.9,36.83
E6  (via drill 0.6)  (2 unrouted)
  Top 0.406: LED9.A 173.99,24.61 R13.2 | Q33.E 167.32,28.25 v167,28.57
  Top 0.61: D19.A 163.19,6.99 MINUS6-.1 167.64,7.62 167.64,8.26 | 167.64,8.26 D44.C | 167.64,8.26 VR46.1
  Top 1.422: B12.- 157,54.61 158.12,54.61 160.02,56.52 160.02,62.23 161.61,63.82 B11.- | B10.+ 173.2,54.61 172.09,54.61 170.18,56.52 170.18,62.87 169.23,63.82 B9.+
  Bottom 0.406: v167,28.57 167.64,28.57 169.54,26.67 173.35,26.67 R13.2
  Bottom 1.27: PLUS5+.1 MINUS6-.1
  Bottom 1.422: B9.+ 167.64,66.04 165.74,63.5 165.74,8.89 164.47,8.89 164.47,63.5 162.56,66.04 B11.-
  Bottom 1.778: Q16.E Q39.E
  Bottom 2.54: R13.2 170.81,27.3 167.64,24.13 167.64,8.26 166.37,6.99 165.74,6.99 165.1,6.35 MINUS6-.1 162.56,7.62 162.56,32.38
  pour Top (isolate 0.813): 156.84,39.37 160.66,39.37 162.56,36.83 161.93,31.11 157.48,31.11 156.84,36.83
E7  (via drill 0.6)  (2 unrouted)
  Top 0.406: LED4.A 154.94,24.61 R14.2
  Top 0.61: Q32.E 148.28,27.62 v147.64,28.45 | D34.A 144.15,6.99 MINUS7-.1 149.22,8.26 | 149.22,8.26 D26.C | 149.22,8.26 VR35.1
  Top 1.422: B14.- 137.95,54.61 139.06,54.61 140.97,56.52 140.97,62.23 142.49,63.75 142.49,63.82 142.56,63.88 B13.- | B12.+ 154.15,54.61 153.03,54.61 151.13,56.52 151.13,62.87 150.18,63.82 B11.+
  Bottom 0.61: 150.18,25.72 v147.64,28.45
  Bottom 1.27: PLUS6+.1 MINUS7-.1
  Bottom 1.422: B11.+ 148.59,66.04 146.69,63.5 146.69,8.26 145.41,8.26 145.41,62.55 B13.-
  Bottom 1.778: Q22.E Q38.E
  Bottom 2.54: R14.2 151.76,27.3 150.18,25.72 148.59,24.13 148.59,8.26 MINUS7-.1 143.51,7.62 143.51,32.38
  pour Top (isolate 0.813): 137.79,39.37 141.6,39.37 143.51,36.83 142.88,31.11 138.43,31.11 137.79,36.83
E8  (via drill 0.6)  (2 unrouted)
  Top 0.406: D13.C 125.09,6.99 MINUS8-.1 129.54,7.62 129.54,8.26 | 129.54,8.26 D35.C | 129.54,8.26 VR36.1 | LED7.A 135.89,24.61 R5.2
  Top 0.61: Q31.E 129.22,27.62 v128.59,28.7
  Top 1.422: B16.- 118.9,54.61 120.02,54.61 121.92,56.52 121.92,62.23 123.51,63.82 B15.- | B14.+ 135.1,54.61 133.99,54.61 132.08,56.52 132.08,62.87 131.13,63.82 B13.+
  Bottom 0.61: 131.13,25.72 v128.59,28.7
  Bottom 1.27: PLUS7+.1 MINUS8-.1
  Bottom 1.422: B13.+ 130.81,66.04 127.64,62.87 127.64,8.26 126.36,7.62 126.36,62.55 B15.-
  Bottom 1.778: Q15.E Q21.E
  Bottom 2.54: R5.2 132.72,27.3 131.13,25.72 129.54,24.13 129.54,7.62 MINUS8-.1 125.09,6.99 124.46,6.99 124.46,32.38
  pour Top (isolate 0.813): 118.75,39.37 122.56,39.37 124.46,36.83 123.83,31.11 119.38,31.11 118.75,36.83
E9  (via drill 0.6)  (2 unrouted)
  Top 0.406: D18.A 106.05,7.62 MINUS9-.1 110.49,7.62 110.49,8.26 | LED8X.A 117.47,26.67 R4.2 | 110.49,8.26 D14.C | 110.49,8.26 VR28.1 | Q2T.E 100.07,39.63
  Top 0.61: Q30.E 110.17,27.62 v109.35,28.38
  Top 1.422: B18.- 99.85,54.61 100.97,54.61 102.87,56.52 102.87,62.23 104.39,63.75 104.39,63.82 104.46,63.88 B17.- | B16.+ 116.05,54.61 114.94,54.61 113.03,56.52 113.03,62.87 112.08,63.82 B15.+
  Bottom 0.61: v109.35,28.38 109.86,27.3 111.76,25.4
  Bottom 1.27: PLUS8+.1 MINUS9-.1
  Bottom 1.422: B15.+ 110.49,66.04 108.58,64.77 108.58,8.89 107.31,8.26 107.31,64.77 106.05,66.04 B17.-
  Bottom 1.778: Q2T.E Q29.E
  Bottom 2.54: 105.41,32.38 105.41,7.62 MINUS9-.1 108.58,5.71 108.58,6.35 110.49,8.26 110.49,24.13 111.76,25.4 113.67,27.3 R4.2
  pour Top (isolate 0.813): 99.69,39.37 103.5,39.37 105.41,36.83 104.78,31.11 100.33,31.11 99.69,36.83
GATE
  Top 0.406: FQFET.1 268.23,35.78 FRGS.2 269.72,33.81 270.51,33.02 270.51,29.84 269.88,29.21 269.88,28.09 FRGTE.1 269.24,27.94 268.61,27.3 FQ1.C
HOT  (via drill 0.6)
  Top 0.406: Q6.C PQ1.2 92.71,86.36 93.34,87 95.25,87 97.16,88.9 v97.16,89.53 P_L1.1 99.39,89.58 P_C6.C
  pour Top (isolate 0.813, hatched): 95.25,92.08 99.06,92.08 100.33,90.81 100.33,84.45 99.69,83.82 93.98,83.82 92.08,85.72 90.81,85.72 90.81,86.36 90.81,87 92.71,87 94.61,88.9 94.61,89.53 95.25,90.17
  pour Bottom (isolate 0.813, hatched): 95.25,92.08 99.06,92.08 100.33,90.81 100.33,84.45 99.69,83.82 93.98,83.82 92.08,85.72 90.81,85.72 90.81,86.36 90.81,87 92.71,87 94.61,88.9 94.61,89.53 95.25,90.17
IN+1
  Top 0.406: 25.1,82.22 V-TO3.1 31.11,81.28 VMABDT.3 | TO92S.3 26.04,62.23 26.04,63.5 V-SO8.1
  Top 0.813: 26.04,59.05 26.04,63.5
  pour Bottom (isolate 0.813, hatched): 43.18,64.14 43.18,59.05 36.07,58.93 37.34,64.01
  pour Top (isolate 0.813, rank 3, hatched): 26.04,100.33 26.04,88.27 30.8,85.72 32.7,78.74 21.59,78.74 18.41,76.83 18.41,71.75 26.04,71.75 29.53,66.74 30.35,65.91 arc139 40.64,64.14 43.18,64.14 43.18,59.05 27.3,59.05 26.04,58.42 26.04,64.14 arc90 22.23,67.94 18.1,68.26 15.24,70.17 15.24,80.01 17.14,81.92 19.68,82.55 arc32 23.5,100.33
  pour Bottom (isolate 0.813, rank 4): 29.21,79.38 15.88,79.38 15.88,81.28 19.68,85.09 20.32,85.09 20.32,89.53 23.5,100.97 26.67,100.97 26.67,87 27.94,85.72 31.75,85.72 31.75,80.64
IN-  (via drill 1.3)
  Top 0.406: VCQ.E 39.35,89.34 VD2.A 40.03,92.12 VR-B.2
  Top 2.54: v203.84,111.12 v40.64,111.12
  Bottom 0.406: 45.72,92.71 VRSHNT.2 43.18,95.89 VIN(-).1
  Bottom 2.54: MINUS120.1 217.88,97.08 v203.84,111.12 | v40.64,111.12 VIN(-).1
  pour Bottom (isolate 0.813, rank 2): 35.56,100.97 46.35,100.97 47.62,98.42 47.62,90.81 35.56,90.81
  pour Top (isolate 0.813, rank 2, hatched): 47.62,100.33 47.62,90.81 40.01,90.81 38.73,93.98 35.56,94.61 35.56,100.33
INPUT+  (via drill 1)
  Top 0.406: C-SO8.1 32.7,40.96 v30.54,41.91 V-TO1.1 | CCIO1.1 CDZIO.C | C-TO92.3 33.02,35.56 | C-SO8.1 33.02,38.73 | 33.02,38.1 C-SO8.1 | v30.48,49.78 CMABDT.3
  Top 0.61: CO1.1 37.47,51.44
  Top 0.813: 33.02,38.1 33.02,35.56 33.02,33.66 | 37.47,51.44 CQHV.E
  Bottom 1.27: C-1083.3 C-TS.3
  pour Top (isolate 0.61, rank 2, hatched): 33.66,52.7 26.67,52.7 26.04,44.45 21.59,44.45 21.59,40.64 22.86,40.64 23.5,40.01 31.75,40.01 31.75,39.37 33.66,39.37
  pour Bottom (isolate 0.813, rank 2, hatched): 43.18,50.8 33.02,52.7 27.94,52.7 27.94,46.35 20.95,41.27 20.95,38.73 22.86,36.83 22.86,34.29 20.95,31.11 20.95,20.32 29.84,20.32 37.47,16.51 41.27,16.51 41.27,23.5 31.11,23.5 25.4,27.3 25.4,37.47 26.67,38.73 33.66,41.27 33.66,48.26 43.18,48.9
  pour Top (isolate 0.813, rank 2): 38.1,20.32 42.55,20.32 42.55,8.26 38.1,8.26
MINUS
  Top 0.406: CTRIM3.A 16.38,12.7 8.89,12.7 8.43,13.16 8.45,20.13 8.45,23.05 8.89,23.5 CDT3L2.C 9.32,24.97 9.53,24.77 9.38,24.77 CD4.2
  Bottom 0.406: TRIM3X.E 16.43,12.73 CTRIM3.A
MINUS10  (via drill 0.6)  (4 unrouted)
  Top 0.406: D10A1.A 86.36,7.62 MINUS10.1 89.53,5.08 91.44,6.99 91.44,8.26 | 91.44,8.26 D9.C | 91.44,8.26 VR21.1 | Q19.E 91.12,28.25 v90.17,28.57 | LED9X.A 98.42,26.67 R3.2
  Top 1.422: B20.- 80.8,54.61 81.92,54.61 83.82,56.52 83.82,62.23 85.41,63.82 B19.- | B18.+ 97,54.61 95.89,54.61 93.98,56.52 93.98,62.87 93.03,63.82 B17.+
  Bottom 0.406: MINUS10.1 89.53,5.08
  Bottom 1.27: PLUS9+.1 MINUS10.1
  Bottom 1.422: B17.+ 92.71,66.04 89.53,62.87 89.53,8.89 88.27,8.26 88.27,62.55 B19.-
  Bottom 1.778: Q1T.E Q1.E
  Bottom 2.54: 86.36,32.38 86.36,7.62 MINUS10.1 90.81,7.62 90.81,23.5 94.61,27.3 R3.2
N$1
  Bottom 0.406: 16.43,60.01 VPOT2.A | 17.27,58.55 VPOT1.E
  Bottom 1.016: VPOT1.E 16.43,60.01
  Bottom 1.27: VO2.2 17.27,58.55
N$2
  Top 0.406: VRT2.2 16.43,66.04 VPOT1.A 14.16,67.18 arc-135 13.34,71.75 VRT3.2
  Bottom 0.813: 16.45,66.4 VPOT1.A
  Bottom 1.27: VPOT2.E 16.45,66.4
N$3
  Top 0.406: VTRIM1.E VRB1.2
  Bottom 0.813: VTRIM1.E 28.89,76.83
  pour Bottom (isolate 0.813, rank 2, hatched): 32.38,78.11 32.38,76.2 33.34,74.93 27.3,74.93 26.67,75.56 26.67,78.11
N$4
  Bottom 0.406: VRT1.1 28.85,69.53 28.85,71.16 | VTRIM1.A 26.46,71.8 VO1.2
  Bottom 0.813: VTRIM1.A 28.85,71.16
  pour Bottom (isolate 0.813, rank 3, hatched): 32.38,73.66 31.11,69.22 29.21,67.31 26.67,67.94 26.67,73.03 27.3,73.66
N$5
  Bottom 0.406: 17.73,18.41 CTRIM3.E 16.43,17.75 TRIM3X.A
  Bottom 0.61: 21,17.74 19.68,18.41 17.73,18.41
  Bottom 0.813: CTRIM2.A 24.13,12.74 CTRIM2.S 21.59,17.14 21,17.74
N$6
  Top 0.813: CRT2H.1 24.2,20.17 CTRIM2.E
N$7
  Top 0.406: VR3X.1 VR3.1
  Bottom 0.406: VR3.1 VCLO.1 VCHI.2
  pour Bottom (isolate 0.813, rank 3): 34.29,90.81 27.3,90.81 27.3,100.97 34.29,100.97
  pour Top (isolate 0.813, rank 4): 34.29,90.81 27.3,90.81 27.3,100.33 34.29,100.33
N$8
  Top 1.27: B3.~1 252.12,63.53 252.73,64.14 252.73,65.72 B1.AC1
  Bottom 1.27: B1.AC1 253.05,68.26 JP1.1
N$9
  Bottom 0.813: CCOUT.- 31.75,11.43 VIN(-)1.1
  pour Bottom (isolate 0.813): 28.57,14.61 37.47,14.61 37.47,9.53 33.66,9.53 32.38,8.26 29.21,8.26 28.57,8.89
  pour Top (isolate 0.813): 28.57,14.61 37.47,14.61 37.47,8.26 29.21,8.26 28.57,8.89
N$10
  Top 0.813: VQHV.B 19.05,96.67 VRHV.1 VZDHV.C
N$11
  Top 0.406: OK10X.2 87,22.23 86.36,22.86 83.82,22.86 82.55,21.59 82.55,21.44 VR14.1 79.7,20.8 LED10X.C
N$12
  Top 0.406: VR3.2 VR3X.2 29.88,87.83 VD-S2.C
  Top 0.813: VR8X.1 VRB1.1 | VO2.1 VRB2.1
  Bottom 0.813: VR3.2 30.42,85.79 33.66,84.45 VR8X.1 33.66,76.47 arc-77 22.29,63.06 21.78,63.06 20.38,61.59 VO2.1
N$13
  Top 0.406: VD-S1.C 31.75,93.34 VD-S2.A
N$14
  Top 0.406: D10A.A 74.72,16.4 VR48.2 75.25,13.65 TRIM10X.A
N$15
  Top 0.406: Q14.C 73.03,22.38 VR11.1
N$16
  Top 0.406: VR28.2 121.92,8.26 123.19,9.53 123.19,15.24 123.83,15.88 123.83,19.36 OK8X.1
N$17
  Top 0.406: D10A.C 71.33,15.46 D10.A
N$18
  Top 0.406: FQHVU.3 271.78,24.77 272.42,25.4 272.42,27.79 FRGTE.2
N$19
  Top 0.406: FRHVT.1 272.57,10.31 271.78,9.53 267.97,9.53 267.33,10.16 FDZHV.A
N$20
  Top 0.406: TRIM9X.A 95.25,12.06 93.98,13.34 93.98,15.55 VR51.1 94.3,17.89 D9A.A
N$21
  Top 0.406: FRHVT.2 FRHVL.1 269.72,16.99 270.51,17.78 270.51,18.27 FQHVU.1
N$22
  Top 0.61: 121.28,99.01 121.28,96.52 121.92,95.89 | 121.92,95.89 D_Q1.2 | DR1.1 121.77,95.73 121.92,95.89
  Top 0.813: P_L1.2 97.16,98.42 97.79,99.06 113.67,99.06 | 121.28,99.01 120.65,99.06 113.67,99.06 | 113.67,99.06 VENTILATOR.1
  Bottom 0.406: VENTILATOR.1 P_C10.+
N$23
  Top 0.406: VR13.2 83.19,8.26 84.45,9.53 84.45,15.24 85.09,15.88 85.09,20 OK10X.1
N$24
  Top 0.406: D8.A 86.79,14.83 D10A1.C
N$25  (1 unrouted)
  Top 0.406: VR49.1 77.47,18.73 77.47,20.32 76.2,22.23 VR11.2 75.72,23.65 76.2,24.77 Q1T.B Q1.B
N$26
  Top 0.406: D15.A 112.83,16.4 VR54.1 113.35,13.65 TRIM8X.A
N$27
  Top 0.406: TRIM8X.E 121.28,13.34 121.28,15.56 VR53.1 121.6,17.57 D12.A
N$29
  Top 0.406: D15.C 109.42,15.46 D14.A
N$31
  Top 0.406: OK8X.2 125.09,22.23 124.46,22.86 120.17,22.86 VR29.1 120.02,21.59 118.75,20.32 117.63,20.32 LED8X.C
N$32
  Top 0.406: D13.A 125.09,15.24 125.73,15.88 125.73,17.89 D12.C
N$33  (1 unrouted)
  Top 0.406: VR55.2 117.16,18.1 115.57,19.68 115.57,20.47 VR12.2 114.3,22.71 Q15.B Q21.B
N$34  (via drill 0.6)
  Top 0.406: 132.06,93.95 LED3.2
  Top 0.61: DC9.+ 148.59,87 IC1.1 U$2.5 | D_Q1.3 130.81,98.09 v131.44,97.79 132.08,96.52 132.06,93.95
  Bottom 0.61: DC9.+ 139.7,88.9 v131.44,97.79
N$35  (via drill 0.6)
  Top 0.406: DR2.2 134.14,78.59 134.62,78.11 167,78.11 170.18,81.28 170.18,96.52 169.54,97.16 v161.93,97.16
  Top 0.61: U$2.1 153.42,91.82 154.31,92.71 IC1.7
  Bottom 0.406: v161.93,97.16 154.94,97.16 154.31,96.52 IC1.7
N$36
  Top 0.406: IC1.6 156.84,96.52 156.21,97.16 149.22,97.16 | 149.22,97.16 139.85,97.16 DR6.2 | U$2.3 150.11,91.82 149.22,92.71 149.22,97.16
N$37  (via drill 0.6)
  Top 0.406: v141.6,79.38 140.49,79.38 DR3.2 | DZD4.C 165.94,80.22 v167,81.28
  Top 0.61: U$2.4 147.7,89.79 146.05,91.44 141.6,91.44 139.7,89.53 139.7,80.49 DR3.2
  Bottom 0.406: IC1.5 163.19,94.61 164.47,95.89 168.91,95.89 170.18,95.25 170.18,81.28 168.91,80.01 | 168.91,80.01 167,78.11 142.24,78.11 v141.6,79.38 | v167,81.28 167.64,81.28 168.91,80.01
N$38
  Top 0.813: PQ1.3 84.86,84.05 83.82,85.09 83.82,85.24 Q6.E 77.28,85.41 PRE.2
N$39
  Top 0.406: 89.07,89.11 88.04,89.94 89.53,91.44 | 89.07,89.11 PQ1.1 | 89.53,91.44 90.84,91.44 | 90.84,91.44 91.44,91.44 | 90.84,91.44 L2.2 | Q6.B 84.14,87.31 86.36,89.53 88.64,89.53 89.07,89.11 | PSOK2.3 72.39,96.52 73.66,98.42 86.36,98.42 87,97.16 87,93.34 88.9,91.44 89.53,91.44
N$40
  Top 1.27: B1.AC2 249.24,63.82 249.56,63.5 249.56,62.13 B3.~2
  Bottom 1.422: JP2.1 248.92,66.36 B1.AC2
N$41
  Top 0.406: PSOK2.2 80.49,96.52 PSR23.2 84.18,96.67 PZDFB.C
N$42
  Top 0.406: PSR22.2 78.89,91.29 78.74,91.44 78.74,92.08 78.11,92.71 78.11,93.67 PSOK2.1
N$43
  Top 0.406: L2.1 88.9,99.69 70.97,99.69 PS16.1 | PS16.1 68.1,96.52 | PS16.1 67.79,96.52 66.04,96.52 64.14,94.61 64.14,85.72 67.31,85.72 68.89,88.58 PCT1.1 PCB.2
N$45
  Top 0.406: Q35.C 205.59,24.15 VR39.1
N$46
  Top 0.61: DZD1.C 124.89,91.16 DR1.2 125.42,91.44 D_Q1.1
N$47
  Top 0.813: DR2.1 131.29,83.15 LED3.1
N$48
  Top 0.61: DR6.1 136.37,91.03 LED3.3
N$49
  Top 0.813: DR3.1 137.01,84.09 LED3.4
N$50  (1 unrouted)
  Top 0.406: Q39.B Q16.B 152.4,22.71 VR25.2 151.92,22.07 153.67,20.32 153.67,19.05 154.31,18.41 VR61.2
N$51  (1 unrouted)
  Top 0.406: Q41.B Q17.B 190.5,22.23 VR26.2 190.65,21.44 192.41,19.68 192.41,19.05 193.04,18.41 VR67.2
N$52  (1 unrouted)
  Top 0.406: VR73.2 230.19,18.1 229.87,19.05 229.87,20.47 VR27.1 227.48,23.01 228.6,24.13 Q18.B Q43.B
N$53
  Top 0.813: VENTILATOR.2 111.12,88.9 P_Q2.2 VTQ1.3
N$54
  Top 0.406: CDT3L1.C 6.35,25.4 6.99,25.4 8.26,27.73 CDT3L2.A
N$55
  Top 0.406: D34.C 144.57,14.61 D33.A
N$56
  Top 0.406: D9.A 91.44,15.24 90.81,15.88 90.81,17.98 D9A.C
N$57
  Top 0.406: TRIM7X.E 140.65,13.65 VR56.1 141.18,16.4 D33.C
N$58  (2 unrouted)
N$59  (2 unrouted)
N$60  (2 unrouted)
N$61  (2 unrouted)
N$62
  Top 0.406: TRIM3-9.A 189.87,13.34 189.87,15.88 VR66.1 189.66,16.4 D27.A
N$63
  Top 0.406: TRIM3-9.E 197.8,13.65 VR65.1 198.32,16.4 D22.C
N$64
  Top 0.406: Q34.B 188.28,26.36 189.23,25.4 189.23,20.95 189.87,20.32 190.5,20.32 191.13,19.68 191.13,18.41 192.41,17.14 192.41,16.2 VR66.2 193.04,15.88 193.68,15.24 | TRIM3-9.S 193.68,15.24 | 193.68,15.24 194.31,15.88 VR65.2 VR67.1
N$65
  Top 0.406: Q31.B 131.12,25.72 131.44,25.4 131.44,20.95 132.08,20.32 132.72,20.32 133.35,19.68 133.35,18.41 134.62,17.14 134.62,16.2 VR57.2 134.62,15.88 136.33,15.3 | 136.33,15.3 136.53,15.24 TRIM7X.S | 136.33,15.3 136.59,15.3 137.16,15.88 VR56.2 139.06,16.19 139.06,17.14 138.75,17.46 VR58.1
N$66
  Top 0.406: TRIM5X.A 151.45,13.65 VR60.1 150.93,16.4 D25.A
N$67
  Top 0.406: Q31.C 130.18,22.38 VR20.1
N$68
  Top 0.406: D19.C 163.62,14.2 D20.A
N$69
  Top 0.406: 144.99,79.38 DZD2.A 144.81,79.61 DTRIM.E
N$70
  Top 0.406: D21.C 201.72,14.83 D22.A
N$71
  Top 0.406: D26.A 147.53,15.46 D25.C
N$72
  Top 0.406: TRIM5X.E 159.7,13.65 VR59.1 160.22,16.4 D20.C
N$73
  Top 0.406: D28.A 186.26,14.61 D27.C
N$74
  Top 0.406: D29.C 223.98,16.69 224.16,15.88 D30.A
N$75
  Top 0.406: U$2.6 156.59,89.79 156.84,89.53 IC1.3 DC2.1 160.04,83.97 DR4.2 162.2,83.61 DZD4.A
N$76
  Top 0.406: DR4.1 161.29,80.01 160.66,79.38 153.03,79.38 152.65,79.76 DTRIM.S
N$77
  Top 0.406: OK6X.2 163.19,21.59 162.08,22.71 VR30.1 158.12,20.95 157.63,20.48 LED4.C
N$78
  Top 0.406: OK4X.2 201.29,22.23 200.81,22.71 VR31.1 196.22,21.59 195.74,21.11 LED5.C
N$79
  Top 0.406: OK2X.2 239.4,22.23 238.76,22.86 234.95,22.86 234.31,22.23 | VR32.1 234.31,22.23 | 234.31,22.23 234.31,21.59 233.84,21.11 LED6.C
N$80
  Top 0.406: OK6X.1 160.66,20.32 161.93,19.05 161.93,15.88 161.29,15.24 161.29,9.53 160.02,8.26 VR35.2
N$81
  Top 0.406: VR33.2 198.12,8.26 199.39,9.53 199.39,15.24 200.03,15.88 200.03,19.05 198.75,20.32 OK4X.1
N$82
  Top 0.406: VR34.2 236.22,8.26 237.49,9.53 237.49,15.24 238.12,15.88 238.12,19.05 236.85,20.32 OK2X.1
N$83
  Top 0.406: DZD3.A 143.92,82.12 DZD2.C
N$84
  Top 0.813: CQHV.B CRHV.1 36.4,44.93 CDZHV.C
N$85  (2 unrouted)
N$86
  Top 0.406: Q19.B 93.03,25.72 93.34,25.4 93.34,20.95 93.98,20.32 94.61,20.32 95.25,19.68 95.25,18.41 96.52,17.14 96.52,16.2 | 96.52,16.2 VR51.2 | 96.52,16.2 99.69,16.2 VR50.2 | VR50.2 VR15.1 | VR50.2 99.06,15.88 98.42,15.24 TRIM9X.S
N$87  (1 unrouted)
  Top 0.406: VR52.2 95.25,22.23 | 95.25,22.23 96.52,20.95 96.52,19.69 VR15.2 | 95.25,22.23 Q2T.B Q29.B
N$88
  Top 0.406: D36.A 131.88,16.4 VR57.1 132.4,13.65 TRIM7X.A
N$89
  Top 0.406: D37.C 182.68,14.83 D38.A
N$90  (2 unrouted)
N$91
  Top 0.406: D35.A 129.54,14.61 128.27,15.88 128.27,18.21 D36.C
N$92
  Top 0.406: Q34.C 187.81,23.82 VR26.1
N$93  (1 unrouted)
  Top 0.406: Q38.B Q22.B 133.35,22.71 VR20.2 132.87,22.07 134.62,20.32 134.62,19.05 135.25,18.41 136.53,18.41 VR58.2
N$94
  Top 0.406: OK9X.2 106.05,22.23 105.41,22.86 102.23,22.86 101.45,22.07 VR24.1 99.37,20.48 LED9X.C
N$95
  Top 0.406: VR21.2 102.87,8.26 103.5,8.89 103.5,15.24 104.14,15.88 104.14,20 OK9X.1
N$96
  Bottom 0.406: SP1.+ 166.37,87.63 164.47,89.53 154.94,89.53 154.31,88.9 IC1.2
N$97  (2 unrouted)
N$98  (2 unrouted)
N$99
  Top 0.406: OK7.1 141.6,20.32 142.88,19.05 142.88,15.88 142.24,15.24 142.24,9.53 140.97,8.26 VR36.2
N$100
  Top 0.406: OK7.2 144.15,21.59 143.03,22.71 VR37.1 138.43,22.07 138.43,20.95 137.95,20.48 LED7.C
N$101  (2 unrouted)
N$102  (1 unrouted)
  Top 0.406: Q40.B Q26.B 171.45,22.71 VR38.2 170.97,22.07 172.72,20.32 172.72,19.05 173.35,18.41 174.63,18.41 VR64.2
N$103  (1 unrouted)
  Top 0.406: Q42.B Q27.B 209.55,24.13 208.43,23.01 VR39.2 208.43,22.07 212.09,18.41 212.73,18.41 VR70.2
N$104  (1 unrouted)
  Top 0.406: SRB.2 249.87,18.1 248.92,19.05 248.92,20.47 SRC.2 247.17,22.38 247.65,22.86 Q28.B Q44.B
N$105
  Top 0.406: Q32.B 150.18,25.72 150.5,25.4 150.5,20.95 151.13,20.32 151.76,20.32 152.4,19.68 152.4,18.41 153.67,17.14 153.67,16.2 | 153.67,16.2 VR60.2 | 155.57,15.24 156.21,15.88 VR59.2 VR61.1 | TRIM5X.S 155.57,15.24 | 153.67,16.2 153.99,15.88 154.94,15.88 155.57,15.24
N$106
  Top 0.406: TRIM2-7.A 170.5,13.65 VR63.1 169.97,16.4 D43.A
N$107
  Top 0.406: Q33.C 168.12,24.15 VR38.1
N$108
  Top 0.406: TRIM1-9.A 227.33,13.97 227.33,14.61 227.65,14.93 VR72.1 227.38,16.78 D29.A
N$109
  Top 0.406: TRIM2-9.E 216.85,13.65 VR68.1 217.38,16.4 D40.C
N$110
  Top 0.406: TRIM2-7.E 179.07,13.97 179.07,14.61 178.75,14.93 VR62.1 179.28,16.4 D38.C
N$111
  Top 0.406: Q33.B 169.22,25.72 169.54,25.4 169.54,20.95 170.18,20.32 170.81,20.32 171.45,19.68 171.45,18.41 172.72,17.14 172.72,16.2 | 172.72,16.2 VR63.2 | 174.62,15.24 175.26,15.88 VR62.2 VR64.1 | TRIM2-7.S 174.62,15.24 | 172.72,16.2 173.04,15.88 173.99,15.88 174.62,15.24
N$112
  Top 0.406: VR25.1 149.07,24.15 Q32.C
N$113
  Top 0.406: Q35.B 206.69,25.72 207.65,25.4 207.65,20.32 208.28,20.32 209.55,19.68 209.55,18.41 210.19,17.14 210.19,16.19 VR69.2 212.09,15.88 212.72,15.24 | TRIM2-9.S 212.72,15.24 | 212.72,15.24 213.36,15.88 VR68.2 VR70.1
N$114  (2 unrouted)
N$115
  Top 0.406: TRIM2-9.A 208.6,13.65 VR69.1 208.27,16.84 D45.A
N$116
  Top 0.406: TRIM1-9.E 235.9,13.65 VR71.1 236.43,16.4 D24.C
N$117  (2 unrouted)
N$118
  Top 0.406: D44.A 166.57,16.1 D43.C
N$119
  Top 0.406: D45.C 204.47,18.18 204.47,15.24 205.31,14.4 D46.A
N$120
  Top 0.406: SDZH1.A 242.78,14.2 SDZH2.C
N$121
  Top 0.406: OK5X.2 182.25,21.59 181.13,22.71 VR41.1 177.16,21.59 176.05,20.48 LED9.C
N$122
  Top 0.406: OK3.2 220.34,22.23 219.86,22.71 VR42.1 215.26,21.59 214.78,21.11 LED10.C
N$123
  Top 0.406: OK1.2 258.44,22.23 257.96,22.71 SRLOKD.1 251.77,21.11 SLED1.C
N$124
  Top 0.406: OK5X.1 179.71,20.32 180.97,19.05 180.97,15.88 180.34,15.24 180.34,9.53 179.07,8.26 VR46.2
N$125
  Top 0.406: OK3.1 219.07,19.36 219.07,15.88 218.44,15.24 218.44,9.53 217.17,8.26 VR44.2
N$126
  Top 0.406: SRHOKD.2 255.27,8.26 256.54,9.53 256.54,15.24 257.18,15.88 257.18,19.05 255.91,20.32 OK1.1
N$127
  Top 0.406: TRIM9X.E 101.6,12.06 102.23,12.7 102.23,15.55 VR50.1 101.92,16.82 102.23,17.14 102.23,17.89 D17.C
N$128
  Top 0.406: TRIM10X.E VR47.1 83.39,16.4 D8.C
N$129
  Top 0.406: D18.C 106.05,17.89 D17.A
N$130
  Top 0.406: Q30.C 111.12,22.38 VR12.1
N$131
  Top 0.406: VR52.1 91.92,24.15 Q19.C
N$132
  Top 0.406: Q30.B 112.08,25.72 112.39,25.4 112.39,20.95 113.03,20.32 113.67,20.32 114.3,19.68 114.3,18.41 115.57,17.14 115.57,16.2 | 115.57,16.2 VR54.2 | 115.57,16.2 117.16,16.2 117.47,15.88 | TRIM8X.S 117.47,15.88 | 117.47,15.88 VR53.2 VR55.1
N$133
  Top 0.406: D40.A 220.98,17.89 220.98,14.61 220.78,14.4 D39.C
N$134
  Top 0.406: Q36.B 225.74,25.72 226.69,25.4 226.69,20.32 227.33,20.32 228.6,19.68 228.6,18.41 229.24,17.14 229.24,16.19 VR72.2 231.14,15.88 231.78,15.24 | VR71.2 | VR71.2 VR73.1 | VR71.2 232.41,15.88 231.78,15.24 | TRIM1-9.S 231.78,15.24
N$135  (2 unrouted)
N$137
  Top 0.406: D23.C 239.82,14.2 D24.A
N$138  (2 unrouted)
N$139  (2 unrouted)
N$140
  Top 0.406: Q36.C 224.64,24.15 VR27.2
N$141
  Top 0.406: STRIM01.A 246.7,13.65 SROH.1 246.18,16.4 SDZH2.A
N$142
  Top 0.406: SDL2.C 255.27,17.89 255.27,15.88 SROL.1 254.63,15.56 254.63,12.7 254,12.06 STRIM01.E
N$143
  Top 0.406: SQ1.B 244.79,26.36 245.75,25.4 245.75,20.95 246.38,20.32 247.01,20.32 247.65,19.68 247.65,18.41 248.92,17.14 248.92,16.2 SROH.2 250.19,15.88 250.82,15.24 | SRB.1 SROL.2 251.46,15.88 250.82,15.24 | STRIM01.S 250.82,15.24
N$144
  Top 0.406: SDL2.A 259.08,17.89 259.08,13.97 258.88,13.77 SDL1.C
N$145
  Top 0.406: SQ1.C 243.84,22.23 SRC.1
N$147  (2 unrouted)
N$148  (2 unrouted)
N$149
  Top 1.27: B20.~1 80.64,62.13 80.64,64.14 81.6,65.09 B19.AC1 81.92,66.36 81.92,68.58 JP19.1
N$150
  Top 1.27: JP20.1 77.79,68.9 B19.AC2 78.11,65.72 78.11,62.87 78.08,62.84 B20.~2
OUT1  (via drill 0.6)
  Top 0.406: 33.02,23.44 V-TO1.3 | C-1083.2 35.83,26.04 V-TO1.3 | C-TO92.2 31.11,34.29 31.75,33.66 C-SO8.7 31.75,31.11 31.43,30.8 | 26.99,32.7 CRLM3.2 | 31.43,30.8 31.11,30.48 V-TO1.3 | CMABDT.4 19.05,49.53 CDZIO.A CCIO1.2 | CRLM2.2 23.61,34.48 | 31.11,31.11 31.43,31.11 31.43,30.8
  Top 0.813: 30.48,31.11 31.11,31.11 31.11,38.1
  Bottom 0.406: 13.59,41.4 13.34,43.18 13.34,45.09 | A..C.A 13.59,41.4 | C-TO92.2 31.11,34.23 31.75,33.28 34.23,33.28 | 37.53,38.04 38.16,38.67 | 13.59,41.4 CCIO1.2
  Bottom 1.27: 38.16,38.67 CQREG.C
  other vias: 24.77,50.8 22.23,50.8 22.23,48.26 24.77,48.26
  pour Top: 26.67,46.35 19.68,46.35 arc-90 17.78,44.45 arc-64 10.16,45.09 9.53,46.99 3.81,47.62 3.81,52.7 26.67,52.7
  pour Bottom (isolate 0.813, hatched): 41.91,26.67 40.64,26.67 38.1,29.21 38.1,29.84 37.47,30.48 33.02,30.48 36.2,33.02 36.83,33.66 36.83,36.2 38.1,37.47 39.37,38.1 39.18,39.56 30.35,39.56 arc74 26.16,35.88 26.16,26.1 arc33 36.83,22.23 37.47,22.23
  pour Top (isolate 0.813, rank 3, hatched): 10.79,45.09 19.05,45.09 19.68,37.47 22.86,34.92 31.11,34.29 38.1,27.3 37.47,22.86 37.47,15.88 29.21,15.88 28.57,19.05 21.59,23.5 13.34,26.67 10.79,29.21
  pour Bottom (rank 3): 26.67,46.35 19.68,40.01 15.88,36.2 11.43,36.2 11.43,41.91 9.53,45.72 3.81,45.72 3.81,52.7 26.67,52.7
  pour Bottom (rank 3): 37.47,18.41 37.47,15.88 29.21,15.88 29.21,19.05 36.83,19.05
OUT2  (via drill 0.6)
  Top 0.406: 24.13,59.05 24.07,59.05 V-SO8.7 | 23.2,65.91 VRT2.1 | VMABDT.4 v39.37,81.92
  Top 0.813: 24.13,59.05 TO92S.2 24.13,65.41 23.2,65.91 | VRT2.1 22.12,68.05 19.39,68.05 17.97,69.22 14.29,69.22 VRT1.2
  Bottom 0.406: V-1083.2 40.2,66.41
  Bottom 1.27: V-1083.2 V-TO3.3 36.01,70.55
  other vias: 41.27,81.92 41.27,83.82 39.37,83.82
  pour Bottom (isolate 0.813, rank 6, hatched): 38.73,64.14 36.83,62.87 35.56,62.87 35.56,62.23 31.11,55.24 31.11,54.61 12.7,54.61 10.79,57.15 10.79,73.66 12.7,78.74 11.43,83.82 3.81,83.82 3.81,100.97 14.61,100.97 18.41,93.34 19.68,90.17 19.68,86.36 19.68,84.45 17.78,84.45 14.61,79.38 14.61,57.15 25.08,60.96 27.94,63.18 31.11,66.67 33.02,69.85 34.29,74.3 34.92,76.2 34.92,86.68 47.62,86.68 47.62,77.91 38.73,77.79
  pour Top (isolate 0.254, rank 2, hatched): 17.14,81.92 11.43,81.92 11.43,83.82 3.81,83.82 3.81,97.16 14.61,97.16 18.41,93.34 19.68,90.17
OUT+
  Top 0.406: A.C C..C C.C
  pour Bottom (isolate 0.813, rank 2, hatched): 10.16,36.2 3.81,36.2 3.81,46.35 8.26,46.35 10.16,42.55
PLUS10
  pour Top (isolate 0.813): 80.64,39.37 84.45,39.37 86.36,36.83 85.72,31.11 81.28,31.11 80.64,36.83
PLUS11  (via drill 0.6, 1.3)
  Top 0.406: LED10X.A 79.38,26.67 R2.2 | Q14.E 71.92,26.5 v70.8,28.19 | FDZHV.C FCB.1 267.84,17.65 269.24,19.05 269.24,21.59 269.88,22.23 269.88,22.71 FQ1.E 269.56,23.18 270.51,24.13 270.51,25.4 271.14,26.04 271.14,29.21 271.78,29.84 271.78,30.96 FRIO.1 271.93,31.9 273.05,33.02 273.05,33.81 FRGS.1 272.57,37.52 FQFET.2 | PSOK2.4 72.39,93.98 73.97,92.39 PCB.1 PSR22.1 76.05,89.69 | 76.05,89.69 76.83,88.27 81.28,88.27 81.28,92.71 80.64,93.34 PSR23.1 | 74.17,86.36 74.17,88.14 v74.3,88.27 76.05,89.69 | 74.17,86.36 PRE.1 | VENT_RT.1 75.56,80.64 74.3,81.28 74.17,86.36 | 72.39,8.26 72.39,7.62 (BATT+).1 | 72.39,8.26 D10.C | 72.39,8.26 VR13.1 | DZD3.C 143.94,85.52 v143.95,85.66
  Top 1.422: B20.+ 77.95,54.61 76.83,54.61 74.93,56.52 74.93,62.87 73.98,63.82 B19.+
  Top 2.54: 272.57,37.52 277.5,42.6 277.5,73.66 269.88,80.01 v173.99,80.01
  Bottom 0.406: 179.86,96.52 S1.2 | v143.95,85.66 127.64,85.72 126.36,87 126.36,102.23 | 65.41,102.23 74.3,102.23 v74.3,88.27
  Bottom 0.813: 71.75,24.13 71.75,27.3 v70.8,28.19
  Bottom 1.27: (BATT+).1 PLUS10+.1
  Bottom 1.422: B19.+ 71.12,66.04 68.58,63.5 68.58,6.99 69.85,5.71
  Bottom 2.54: S1.2 180.34,97.79 175.9,102.23 126.36,102.23 65.41,102.23 60.33,97.16 60.33,13.97 69.22,5.08 (BATT+).1 69.85,5.71 71.75,6.35 71.75,24.13 72.39,24.13 75.56,27.3 R2.2 | v173.99,80.01 173.99,93.34 177.16,96.52 179.86,96.52
Q0C  (via drill 1)
  Top 0.406: Q44.C 250.19,32.38 253.37,29.21 SRLOKD.2
  Top 0.813: Q23.4 250.19,50.8 v248.92,46.99
  Bottom 1.27: 250.19,36.2 250.19,42.55
  other vias: 251.46,46.99 251.46,44.45 248.92,44.45
  pour Bottom (isolate 0.813, hatched): 259.08,62.23 259.08,40.01 250.19,35.56 241.3,40.01 241.3,62.23
  pour Top (isolate 0.61, rank 2): 257.81,55.24 257.81,41.91 241.3,41.91 241.3,74.93 251.46,74.93 251.46,71.12 243.84,71.12 243.84,55.24
  pour Top (isolate 0.61, rank 2): 238.76,55.24 238.76,41.91 222.25,41.91 222.25,74.93 232.41,74.93 232.41,71.12 224.79,71.12 224.79,55.24
  pour Top (isolate 0.61, rank 2): 219.71,55.24 219.71,41.91 203.2,41.91 203.2,74.93 213.36,74.93 213.36,71.12 205.74,71.12 205.74,55.24
  pour Top (isolate 0.61, rank 2): 200.66,55.24 200.66,41.91 184.15,41.91 184.15,74.93 194.31,74.93 194.31,71.12 186.69,71.12 186.69,55.24
  pour Top (isolate 0.61, rank 2): 181.61,55.24 181.61,41.91 165.1,41.91 165.1,74.93 175.26,74.93 175.26,71.12 167.64,71.12 167.64,55.24
  pour Top (isolate 0.61, rank 2): 162.56,55.24 162.56,41.91 146.05,41.91 146.05,74.93 156.21,74.93 156.21,71.12 148.59,71.12 148.59,55.24
  pour Top (isolate 0.61, rank 2): 143.51,55.24 143.51,41.91 127,41.91 127,74.93 137.16,74.93 137.16,71.12 129.54,71.12 129.54,55.24
  pour Top (isolate 0.61, rank 2): 124.46,55.24 124.46,41.91 107.95,41.91 107.95,74.93 118.11,74.93 118.11,71.12 110.49,71.12 110.49,55.24
  pour Top (isolate 0.61, rank 2): 105.41,55.24 105.41,41.91 88.9,41.91 88.9,74.93 99.06,74.93 99.06,71.12 91.44,71.12 91.44,55.24
  pour Top (isolate 0.61, rank 2): 86.36,55.24 86.36,41.91 69.85,41.91 69.85,74.93 80.01,74.93 80.01,71.12 72.39,71.12 72.39,55.24
  pour Bottom (isolate 0.813, hatched): 240.03,62.23 240.03,40.01 231.14,35.56 222.25,40.01 222.25,62.23
Q1C  (2 unrouted)
  Top 0.406: VR14.2 81.92,30.48 Q1.C
Q2C  (2 unrouted)
  Top 0.406: Q43.C 231.14,31.75 234.31,28.57 VR32.2
Q3C  (2 unrouted)
  Top 0.406: Q42.C 212.09,31.75 215.26,28.57 VR42.2
Q4C  (2 unrouted)
  Top 0.406: Q41.C 193.04,32.38 196.22,29.21 VR31.2
Q5C  (2 unrouted)
  Top 0.406: Q40.C 173.99,32.38 177.16,29.21 VR41.2
Q6C  (2 unrouted)
  Top 0.406: Q39.C 154.94,33.02 158.12,29.84 VR30.2
Q7C  (2 unrouted)
  Top 0.406: Q38.C 135.89,32.38 139.06,29.21 VR37.2
Q8C  (2 unrouted)
  Top 0.406: Q21.C 116.84,33.02 120.02,29.84 VR29.2
Q9C  (2 unrouted)
  Top 0.406: VR24.2 100.97,29.84 97.79,33.02 Q29.C
V+OUT
  Top 0.406: FRBOUT.1 267.33,31.11 268.29,31.37 268.61,31.6 FRIO.2
  Top 0.813: FRFS.1 264.16,60.96 264.16,36.35 FRBOUT.1
  Bottom 0.406: VOUT(+)1.1 237.49,108.58 238.12,107.95
  Bottom 0.61: F2.2B 270.89,67.56 FRFS.1 268.35,67.94 F2.2A
  Bottom 2.54: PLUS120.1 237.62,107.44 238.12,107.95 240.03,109.86 269.88,109.86 275.59,104.14 275.59,81.92 270.51,76.83 FRFS.1
V-
  Top 0.813: VR-B.1 39.66,87.72 VCQ.B
  Top 1.778: VR-B.1 45,87.72 46.35,87 VRSHNT.1 46.35,59.05 44.45,57.15 VOUT-.1
  Bottom 2.54: S1.4 190.98,109.37 189.23,111.12 53.34,111.12 51.44,109.22 51.44,64.14 44.45,57.15 VOUT-.1 37.47,57.15 37.08,57.53 VCOUT.-
VENTB
  Top 0.305: OK1.3 258.44,27.5 | 259.71,75.56 259.71,29.91
  Top 0.406: OK10X.3 87,28.57 88.27,29.84 88.27,74.3 90.81,76.83 107.31,76.83 | 105.89,82.55 VENT_RB.1 106.35,82.4 108.58,82.4 | 106.05,27.94 OK9X.3 106.05,28.57 107.31,29.84 107.31,76.83 | 126.36,76.83 109.86,76.83 | 109.86,76.83 107.31,76.83 | 259.71,75.56 257.81,76.83 240.66,76.83 | 183.51,76.83 202.56,76.83 | 202.56,76.83 221.62,76.83 | 221.62,76.83 240.66,76.83 | 183.51,76.83 165.1,76.83 | 165.1,76.83 145.48,76.83 | 145.48,76.83 126.36,76.83 | 145.48,76.83 145.48,29.91 144.15,28.57 OK7.3 | OK6X.3 163.19,28.57 164.47,29.84 164.47,76.2 165.1,76.83 | 182.25,27.94 OK5X.3 182.25,28.57 183.51,29.84 183.51,76.83 | 201.29,27.94 OK4X.3 201.29,28.57 202.56,29.84 202.56,76.83 | 220.34,27.94 OK3.3 220.34,28.57 221.62,29.84 221.62,76.83 | 239.4,27.94 OK2X.3 239.4,28.57 240.66,29.84 240.66,76.83 | 109.86,76.83 110.17,77.16 VTQ1.1 109.69,79.55 108.58,80.64 108.58,82.4 | 108.58,82.4 P_Q2.1 | 259.71,29.91 259.71,29.84 258.44,28.57 OK1.3 | 126.36,76.83 126.36,29.84 125.09,28.57 OK8X.3
VENTMID  (via drill 0.6)
  Top 0.406: v87.31,75.56 87.31,30.35 86.81,29.84 85.72,29.84 84.45,28.57 OK10X.4 | VENT_RT.2 93.98,78.59 95.1,78.59 v95.25,78.74 VZD1.C | 103.5,27.94 OK9X.4 103.5,28.57 104.71,29.78 105.79,29.78 106.36,30.35 106.36,74.93 105.73,75.88 v105.66,75.56 | v124.46,75.56 125.41,74.93 125.41,30.35 124.9,29.84 123.83,29.84 122.56,28.57 OK8X.4 | v256.54,75.56 258.76,74.8 258.76,30.35 258.25,29.84 257.24,29.84 257.18,29.78 257.11,29.78 255.91,28.57 OK1.4 | OK7.4 141.6,28.57 142.88,29.84 144.02,29.84 144.46,30.29 144.46,73.6 v143.38,75.56 | 160.66,27.94 OK6X.4 160.66,28.57 161.93,29.84 163,29.84 163.51,30.35 163.51,74.3 162.94,75.18 v162.94,75.63 | OK5X.4 179.71,28.57 180.97,29.84 182.05,29.84 182.56,30.35 182.56,73.66 v182.05,75.5 | 198.75,27.94 OK4X.4 198.75,28.57 199.96,29.78 201.04,29.78 201.61,30.35 201.61,73.66 v201.04,75.56 | 217.81,27.94 OK3.4 217.81,28.57 219.07,29.84 220.16,29.84 220.66,30.35 220.66,73.66 v220.09,75.56 | OK2X.4 236.85,28.57 238.12,29.84 239.2,29.84 239.71,30.35 239.71,73.66 v239.08,75.56
  Bottom 0.406: 95.25,75.56 v87.31,75.56 | 95.25,75.56 v95.25,78.74 | 95.25,75.56 v105.66,75.56 v124.46,75.56 v143.38,75.56 163.19,75.56 | 182.25,75.56 v201.04,75.56 v220.09,75.56 v239.08,75.56 v256.54,75.56 | 182.25,75.56 163.19,75.56 | 163.19,75.56 v162.94,75.63 | v182.05,75.5 182.25,75.56
VIN+  (via drill 1.3)
  Top 0.406: VRHV.2 21.74,94.13 VIN(+).1
  Top 1.778: 21.59,101.6 VQHV.C
  Top 2.54: v189.87,83.82 177.16,83.82 173.99,87 173.99,104.14 171.45,106.68 26.67,106.68 21.59,101.6
  Bottom 1.27: VQHV.C VIN(+).1
  Bottom 2.54: VIN(+).1 VIN+1.1 | S1.6 190.98,84.94 v189.87,83.82
VIRT-
  Top 0.406: VD2.C 35.67,92.39 VD-S1.A
  Top 0.813: VCAD.- VD2.C 36.83,88.9 VCQ.C
  Bottom 0.813: VCIN.- 26.67,87.63 28.57,89.53 31.11,89.53 31.75,90.17 33.18,90.17 VCAD.-
  pour Top: 38.1,93.98 38.1,88.27 35.56,88.27 33.02,90.17 34.92,92.08 34.92,93.98
  pour Bottom (isolate 0.813): 36.2,93.98 38.1,92.08 38.1,88.27 25.4,85.72 22.86,87.63 34.92,92.08 34.92,93.98
VOUT+REG
  Bottom 2.54: S1.1 178.23,105.61 177.16,106.68 60.96,106.68 55.88,101.6 55.88,62.23 46.99,53.34 VOUT(+)REG.1
  pour Top (isolate 0.813, hatched): 43.18,52.07 38.73,52.07 arc25 33.02,53.98 31.11,54.61 12.7,54.61 arc-73 3.81,66.67 3.81,80.64 13.97,80.64 11.43,67.94 15.24,65.41 15.24,58.42 19.05,57.15 34.92,57.15 43.18,55.88

## Text on the board
Top: 14042012 | MICHAEL5.net
Bottom: MICHAEL5.net | 14042012
tNames: V_in(+)
tStop: MICHAEL5.net
tTest: V_out(+)